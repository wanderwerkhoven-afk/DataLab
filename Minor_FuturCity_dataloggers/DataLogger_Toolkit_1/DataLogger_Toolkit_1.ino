#include <WiFiS3.h>
#include <Wire.h>
#include <SPI.h>
#include <SD.h>
#include <RTClib.h>
#include <TinyGPSPlus.h>

// =========================
// DataLogger Toolkit 1 - UNO R4 WiFi
// Full source restored 2026-11-18
// Hardware: Keyes Logging Shield + GPS + MAX4466
// GPS: Air530Z on Serial1 (UART)
// MAX4466: analoge uitgang op A0, voeding 3.3V
// RTC: DS1307 I2C 0x68
// SD: Keyes shield CS pin 10
// =========================

const char WIFI_SSID[] = "Arduino-Logger-01";
const char WIFI_PASS[] = "Logger2026!";
const uint8_t SD_CS_PIN = 10;
const uint32_t GPS_BAUD = 9600;
const char LOG_DIR[] = "/DATALOG";
const float SD_NOMINAL_CAPACITY_MB = 32768.0f; // 32 GB kaart; vrije ruimte is een benadering op basis van gelogde bestanden.

WiFiServer server(80);
RTC_DS1307 rtc;
TinyGPSPlus gps;

bool sdReady=false, rtcReady=false, sensorReady=false, rtcSynced=false;
bool gpsSeen=false;
const uint8_t SOUND_PIN=A0;
float liveSoundMv=NAN;
uint16_t liveSoundAdc=0;
float liveSoundBiasV=NAN;
uint32_t lastSensorReadMs=0;

enum SessionState : uint8_t { STATE_IDLE, STATE_RUNNING, STATE_PAUSED };
SessionState sessionState=STATE_IDLE;
uint32_t sessionId=0, measurementCount=0, intervalMs=100;
uint32_t runStartedMs=0, accumulatedRunMs=0, lastMeasureMs=0, lastFlushMs=0;
File sessionFile;

// Exact HTML-handleiding, lossless gecomprimeerd om flash te besparen.
static const uint32_t MANUAL_RAW_LEN=22944;
static const uint8_t MANUAL_LZ[] = {
  16,60,33,100,111,99,116,121,112,101,32,104,116,109,108,62,10,60,144,7,9,32,108,97,
  110,103,61,34,110,108,34,144,17,26,101,97,100,62,10,32,32,60,109,101,116,97,32,99,
  104,97,114,115,101,116,61,34,117,116,102,45,56,128,32,208,25,21,110,97,109,101,61,34,
  118,105,101,119,112,111,114,116,34,32,99,111,110,116,101,110,128,41,12,119,105,100,116,104,
  61,100,101,118,105,99,101,45,160,13,15,44,105,110,105,116,105,97,108,45,115,99,97,108,
  101,61,49,240,70,192,70,10,116,104,101,109,101,45,99,111,108,111,114,240,73,6,34,35,
  51,52,51,70,53,192,116,25,116,105,116,108,101,62,84,111,111,108,107,105,116,32,49,32,
  194,183,32,71,101,108,117,105,100,32,128,72,1,101,110,144,6,15,32,100,101,32,68,97,
  116,97,76,111,103,103,101,114,60,47,176,51,144,61,2,115,116,121,176,10,7,32,32,58,
  114,111,111,116,123,160,11,8,32,32,45,45,110,97,118,121,58,192,105,0,59,240,22,128,
  22,12,45,100,101,101,112,58,35,50,55,51,50,52,55,240,27,1,111,114,129,43,8,101,
  58,35,70,67,66,48,51,49,240,24,4,99,114,101,97,109,128,23,4,54,70,50,69,65,
  240,23,4,112,97,112,101,114,128,23,160,1,240,23,2,105,110,107,128,91,0,51,144,2,
  240,21,12,109,117,116,101,100,58,35,54,54,55,48,56,53,240,23,2,108,105,110,128,112,
  4,68,67,69,49,69,240,163,5,45,103,114,101,101,110,128,68,4,70,65,69,55,66,240,
  23,0,114,144,66,4,67,57,52,66,52,240,21,3,45,98,108,117,128,66,5,52,66,55,
  66,69,67,240,22,15,115,104,97,100,111,119,58,48,32,49,50,112,120,32,51,52,128,5,
  17,114,103,98,97,40,51,50,44,52,50,44,54,49,44,46,49,48,41,240,47,7,114,97,
  100,105,117,115,58,50,128,45,176,21,0,125,160,6,19,42,123,98,111,120,45,115,105,122,
  105,110,103,58,98,111,114,100,101,114,45,128,18,176,29,146,92,18,123,115,99,114,111,108,
  108,45,98,101,104,97,118,105,111,114,58,115,109,129,130,0,104,176,33,3,98,111,100,121,
  209,141,7,109,97,114,103,105,110,58,48,208,115,0,102,130,8,8,45,102,97,109,105,108,
  121,58,73,130,19,30,114,44,117,105,45,115,97,110,115,45,115,101,114,105,102,44,45,97,
  112,112,108,101,45,115,121,115,116,101,109,44,66,129,39,4,107,77,97,99,83,160,15,0,
  70,128,60,20,44,34,83,101,103,111,101,32,85,73,34,44,82,111,98,111,116,111,44,65,
  114,130,134,0,44,240,68,208,107,14,98,97,99,107,103,114,111,117,110,100,58,118,97,114,
  40,193,206,224,253,162,153,192,26,128,102,224,24,145,154,10,45,104,101,105,103,104,116,58,
  49,46,54,241,23,8,32,32,46,116,111,112,98,97,114,208,220,2,112,111,115,131,2,9,
  111,110,58,115,116,105,99,107,121,59,128,30,128,233,0,122,128,78,4,100,101,120,58,50,
  224,244,240,137,0,58,161,140,0,53,129,137,7,51,44,56,56,44,46,57,54,240,143,160,
  143,2,35,102,102,240,192,128,55,7,100,114,111,112,45,102,105,108,129,41,0,58,129,241,
  1,114,40,145,215,224,52,225,154,5,116,116,111,109,58,49,129,236,2,115,111,108,131,61,
  160,102,3,50,53,53,44,208,4,2,46,48,56,192,53,240,201,128,201,128,170,1,110,101,
  224,207,2,109,97,120,179,218,4,58,49,49,50,48,130,17,193,188,3,97,117,116,111,208,
  114,19,100,105,115,112,108,97,121,58,102,108,101,120,59,97,108,105,103,110,45,105,129,154,
  2,115,58,99,131,221,4,101,114,59,106,117,129,12,1,102,121,131,246,163,239,3,58,115,
  112,97,132,48,3,98,101,116,119,130,217,208,69,4,103,97,112,58,50,130,154,4,59,112,
  97,100,100,146,98,0,49,146,167,160,18,240,164,2,32,46,98,131,149,1,100,123,162,49,
  0,119,177,143,3,56,48,48,59,160,16,130,154,0,101,129,97,128,49,2,108,101,116,128,
  120,0,45,144,104,144,74,5,45,46,48,50,101,109,240,65,2,110,100,32,128,27,1,110,
  123,241,237,211,237,0,41,241,10,132,25,0,123,240,217,128,217,144,161,0,56,128,93,144,
  13,2,45,119,114,128,14,144,5,240,49,128,49,1,32,97,209,55,241,185,4,59,116,101,
  120,116,132,98,0,99,128,98,162,24,3,110,111,110,101,240,177,2,58,49,51,144,84,240,
  208,1,58,55,128,208,210,76,193,11,128,119,1,32,49,129,202,0,59,193,220,195,161,0,
  49,144,236,241,29,240,134,3,58,104,111,118,129,195,242,99,178,99,241,253,177,253,192,54,
  3,104,101,114,111,208,184,240,51,0,58,192,18,1,32,32,144,110,133,210,0,103,144,8,
  129,191,18,40,99,105,114,99,108,101,32,97,116,32,56,50,37,32,49,53,37,44,210,92,
  15,50,44,49,55,54,44,52,57,44,46,50,56,41,44,32,116,129,84,129,105,0,114,128,
  53,5,32,50,54,37,41,44,224,83,147,79,130,106,224,83,6,49,51,53,100,101,103,44,
  177,139,229,147,0,41,240,17,1,121,41,243,20,241,91,240,252,176,198,242,187,144,1,242,
  187,242,187,226,187,209,91,0,54,210,102,2,32,53,54,209,78,242,210,4,103,114,105,100,
  59,144,5,0,45,130,208,128,18,0,116,166,187,2,117,109,110,129,125,7,46,50,53,102,
  114,32,46,55,128,6,162,28,0,52,149,47,242,254,226,254,240,165,8,32,46,101,121,101,
  98,114,111,119,208,162,208,103,1,105,110,164,96,243,64,240,66,144,66,210,122,245,46,210,
  60,144,115,242,60,179,12,242,253,162,253,1,46,49,130,252,178,133,161,144,6,102,111,114,
  109,58,117,112,134,172,3,99,97,115,101,241,85,161,85,5,70,56,68,57,57,53,193,41,
  228,67,246,8,160,6,1,104,49,179,128,160,131,6,99,108,97,109,112,40,51,128,159,5,
  44,54,118,119,44,54,128,9,1,41,59,245,46,149,46,1,48,50,240,148,227,145,1,52,
  53,128,150,214,8,2,32,48,32,145,161,193,37,0,108,136,150,240,98,2,58,49,57,161,
  187,209,204,0,55,161,203,192,176,4,69,57,69,68,70,208,176,1,58,48,242,11,5,111,
  45,99,97,114,100,242,214,243,9,243,9,195,9,246,251,197,59,245,52,245,52,240,46,245,
  157,243,141,167,46,244,188,0,103,176,13,167,46,183,122,178,200,176,13,0,41,241,75,240,
  171,4,100,32,104,51,123,241,15,0,32,148,253,244,37,1,58,49,130,156,192,50,4,115,
  112,101,99,45,242,68,245,125,146,61,245,106,245,106,245,106,146,72,0,49,242,73,228,95,
  148,72,1,32,48,212,93,246,57,241,5,241,5,177,5,0,50,225,5,240,164,160,179,240,
  220,240,170,10,58,108,97,115,116,45,99,104,105,108,100,136,66,240,100,0,109,225,177,208,
  42,165,151,3,58,102,105,114,224,48,193,232,5,67,66,68,51,69,52,240,46,192,46,4,
  116,114,111,110,103,246,13,195,1,162,236,163,71,1,58,114,144,21,176,55,3,109,97,105,
  110,129,98,244,19,244,19,244,19,161,15,169,32,164,19,0,56,226,149,2,115,101,99,149,
  189,242,81,248,70,161,219,169,253,0,41,193,67,241,60,177,60,247,219,231,114,242,62,178,
  62,176,70,176,13,0,41,240,138,240,163,179,37,242,87,242,87,242,87,225,123,1,104,50,
  243,64,1,58,50,145,242,243,129,211,129,0,51,243,128,162,113,224,235,130,137,240,61,195,
  125,160,39,161,19,240,42,130,64,210,178,150,160,178,180,209,163,177,47,133,144,129,163,247,
  104,128,173,170,250,0,41,243,208,2,58,56,53,240,229,210,24,154,122,192,74,149,125,231,
  136,245,143,245,143,197,143,10,114,101,112,101,97,116,40,51,44,49,102,129,136,162,234,243,
  52,144,51,4,46,116,119,111,123,240,60,240,60,224,60,134,190,128,60,192,51,244,63,244,
  23,225,214,176,203,148,230,209,243,231,147,145,109,227,88,144,13,242,43,246,180,211,34,163,
  249,3,46,110,117,109,208,106,177,19,0,51,150,138,197,63,160,12,240,100,160,100,168,10,
  240,87,248,193,136,193,246,194,244,23,246,84,246,84,244,42,180,42,192,23,243,76,2,116,
  58,57,131,76,241,152,246,10,240,193,176,193,244,186,146,73,144,176,242,64,1,49,55,225,
  133,160,44,0,112,242,92,180,49,242,28,242,28,245,206,144,56,142,150,1,100,119,136,69,
  129,112,1,115,116,242,11,242,11,241,207,241,207,225,207,178,11,242,80,208,78,245,63,241,
  40,176,44,144,150,241,49,0,115,160,26,5,45,115,116,97,114,116,243,187,242,16,242,16,
  242,16,241,172,162,133,242,16,232,98,192,141,0,105,129,126,208,137,144,103,161,65,168,72,
  178,9,160,11,194,9,160,12,240,93,160,93,154,59,244,146,226,103,1,70,52,142,156,1,
  57,59,241,43,129,43,128,10,134,10,242,3,129,236,241,123,201,99,240,156,192,156,4,32,
  115,118,103,123,176,139,0,50,144,108,192,139,144,12,241,79,161,79,213,140,208,116,4,98,
  108,111,99,107,240,36,192,36,3,109,97,108,108,240,35,144,35,240,133,242,0,194,116,157,
  57,240,105,2,119,105,114,129,67,245,128,240,238,5,70,56,70,65,70,67,245,123,241,149,
  241,149,241,185,241,63,243,172,167,178,148,134,155,54,1,102,108,133,89,252,222,240,127,6,
  101,45,116,97,98,108,101,193,16,3,49,48,48,37,209,143,128,196,3,108,97,112,115,137,
  13,192,9,1,59,109,128,192,176,40,1,53,54,248,217,240,69,3,32,116,104,44,240,15,
  128,15,1,100,123,226,37,128,244,183,255,247,44,247,144,240,217,176,217,246,236,3,58,108,
  101,102,198,235,240,90,144,105,243,114,179,192,250,11,250,11,170,11,246,36,186,57,1,48,
  56,134,35,241,160,209,160,240,100,224,100,0,114,247,227,0,100,144,204,240,186,247,230,2,
  32,46,112,135,129,243,118,250,249,136,161,162,11,209,2,150,103,150,119,241,174,145,174,245,
  76,177,247,4,69,69,70,49,70,207,137,255,184,242,204,160,246,13,102,97,109,105,108,121,
  58,117,105,45,109,111,110,111,169,14,3,44,83,70,77,128,12,14,45,82,101,103,117,108,
  97,114,44,77,101,110,108,111,44,224,31,245,2,184,78,242,5,148,194,4,108,108,111,117,
  116,246,23,160,160,145,120,1,58,53,241,158,245,142,148,14,240,178,6,35,70,70,70,56,
  69,56,242,140,240,222,130,140,250,62,180,40,0,32,162,158,197,11,144,12,137,161,240,140,
  224,140,3,46,103,111,111,225,112,241,5,0,45,141,91,137,242,240,128,161,50,0,70,131,
  41,0,54,240,64,160,64,131,153,0,110,240,64,185,109,4,57,56,53,49,54,240,59,176,
  187,1,55,69,240,59,176,59,0,100,144,227,142,102,240,61,208,125,0,114,147,199,240,64,
  160,64,2,49,70,49,240,64,144,64,244,51,244,16,0,107,246,113,162,59,248,82,147,151,
  242,62,244,217,246,4,246,4,246,4,0,53,246,4,175,45,245,216,1,115,58,128,127,3,
  101,116,99,104,241,86,192,102,133,236,1,101,112,244,105,240,197,1,70,55,148,107,244,105,
  241,242,243,144,241,214,245,254,209,214,235,32,251,54,255,255,255,255,250,194,147,214,197,172,
  246,167,247,207,245,204,247,207,247,207,254,124,240,220,3,119,45,97,114,156,59,208,78,3,
  110,111,110,101,176,30,5,99,111,100,101,44,112,135,23,243,55,243,55,243,55,243,55,179,
  55,2,67,111,110,129,4,1,97,115,243,64,202,26,247,97,241,66,7,58,35,50,48,50,
  57,51,66,221,189,129,80,0,57,229,185,241,51,241,51,252,173,128,1,245,156,149,156,241,
  65,161,65,254,113,158,113,1,53,53,240,249,128,249,3,97,112,112,45,128,145,2,118,105,
  101,242,66,242,66,242,66,242,66,242,66,248,70,200,26,240,89,3,32,46,116,105,134,15,
  192,82,149,242,208,129,249,180,254,30,146,126,240,215,240,215,242,78,242,78,226,78,241,246,
  129,246,168,136,0,100,133,118,171,91,150,108,128,168,241,249,253,242,253,242,240,174,192,174,
  3,46,112,114,105,131,98,1,121,123,241,150,250,63,180,177,243,206,1,114,58,166,38,0,
  112,135,187,0,110,214,90,160,69,3,100,97,114,107,240,66,208,66,181,119,193,220,154,234,
  240,75,240,75,240,75,160,75,143,237,3,97,98,101,108,246,163,177,207,244,76,246,117,240,
  127,144,127,208,57,192,111,5,68,53,68,67,69,65,240,37,128,89,3,118,97,108,117,194,
  207,160,89,173,76,243,105,186,223,246,243,253,23,0,109,240,71,128,71,2,115,117,98,240,
  69,183,65,240,158,240,158,240,158,176,158,144,55,254,188,254,188,4,99,104,101,99,107,250,
  201,226,131,212,161,248,252,162,111,240,54,1,99,107,242,188,242,21,176,57,156,16,244,20,
  250,178,138,178,226,115,128,185,184,86,242,120,242,120,242,120,244,198,242,188,184,141,241,239,
  145,221,242,89,1,32,46,142,145,217,21,151,183,211,6,247,195,0,58,144,125,240,102,210,
  43,240,102,144,102,135,66,162,227,190,142,254,119,161,12,251,192,2,99,115,118,241,144,251,
  217,5,32,46,109,101,116,97,209,35,241,162,234,85,240,52,162,98,240,92,191,32,245,114,
  197,59,240,225,133,58,1,111,111,128,18,244,209,242,249,224,206,4,45,100,101,101,112,242,
  254,130,254,234,89,151,188,175,185,240,100,240,100,240,100,160,100,215,20,240,193,227,154,176,
  40,6,64,109,101,100,105,97,40,255,63,175,63,0,41,208,156,4,46,104,101,114,111,143,
  118,0,110,128,175,244,215,244,215,129,205,1,102,114,176,74,128,45,144,34,0,44,239,29,
  0,44,253,106,146,161,0,44,245,56,133,56,240,77,240,77,240,77,160,193,151,161,240,39,
  240,39,240,39,144,39,129,114,129,48,246,130,230,130,240,224,1,105,97,134,64,1,105,110,
  233,104,144,52,7,98,97,114,123,112,111,115,105,164,251,130,219,2,116,105,99,208,83,2,
  98,111,100,244,208,194,159,208,28,0,115,181,45,136,164,131,17,2,104,97,100,134,63,144,
  114,5,59,98,114,101,97,107,129,40,9,115,105,100,101,58,97,118,111,105,100,224,161,145,
  66,0,123,160,128,180,186,2,45,97,100,149,100,6,58,101,120,97,99,116,59,132,61,3,
  98,107,105,116,129,24,240,33,240,33,0,99,196,220,224,180,0,44,210,60,240,48,240,48,
  240,81,240,81,240,33,240,81,160,1,1,109,97,139,62,194,84,217,30,150,85,241,61,14,
  60,47,115,116,121,108,101,62,10,60,47,104,101,97,100,128,8,145,26,128,7,144,14,130,
  91,0,99,135,168,2,115,61,34,176,153,1,34,62,144,50,2,100,105,118,240,23,144,23,
  178,59,160,29,240,31,144,31,0,98,130,133,7,100,34,62,68,97,116,97,60,133,46,4,
  110,62,76,111,103,137,253,128,116,144,13,7,32,194,183,32,84,111,111,108,128,201,3,32,
  49,60,47,128,56,192,66,129,235,240,97,145,249,192,91,128,27,12,97,32,104,114,101,102,
  61,34,35,100,111,101,108,128,90,128,6,2,60,47,97,240,31,208,31,210,149,2,34,62,
  72,192,10,240,39,240,39,1,35,97,134,95,1,108,117,133,0,3,110,34,62,65,224,12,
  240,43,240,43,4,35,115,111,102,116,176,82,0,83,192,10,240,39,240,39,0,35,132,81,
  144,77,0,77,144,7,240,33,240,33,10,35,103,114,97,102,105,101,107,34,62,71,176,9,
  240,37,240,37,3,35,112,114,111,141,35,0,109,144,74,0,80,208,11,224,41,1,60,47,
  129,19,161,138,177,52,177,186,4,101,114,62,10,10,241,125,1,61,34,146,147,241,177,240,
  21,195,234,241,175,193,119,240,41,144,41,3,101,121,101,98,137,245,177,189,2,76,97,98,
  145,173,6,72,111,103,101,115,99,104,129,179,133,146,3,110,32,65,109,138,244,3,114,100,
  97,109,241,188,144,69,2,104,49,62,241,214,4,98,114,62,71,101,129,86,1,100,32,161,
  25,128,171,0,49,224,41,0,112,208,108,0,108,128,191,145,169,4,110,100,108,101,105,146,
  171,9,32,118,111,111,114,32,104,101,116,32,130,96,6,111,117,119,101,110,44,32,241,171,
  0,32,128,3,0,103,128,158,2,117,105,107,128,10,144,138,2,100,101,32,160,167,162,94,
  144,106,0,32,136,199,7,32,77,65,88,52,52,54,54,137,101,2,99,114,111,131,82,16,
  110,109,111,100,117,108,101,44,32,71,80,83,44,32,82,84,67,144,73,12,83,68,45,111,
  112,115,108,97,103,46,60,47,112,209,96,242,139,241,18,177,59,0,99,130,78,242,142,1,
  104,51,208,235,153,74,4,102,105,103,117,114,132,100,130,25,128,25,241,84,224,66,4,115,
  112,101,99,45,161,85,179,14,240,180,195,18,0,60,181,201,19,62,65,114,100,117,105,110,
  111,32,85,78,79,32,82,52,32,87,105,70,105,147,168,160,28,240,158,240,94,240,94,240,
  94,2,62,83,101,139,102,240,90,176,62,193,20,240,78,240,78,240,78,240,78,240,78,3,
  65,110,97,108,129,255,0,32,129,158,134,89,240,86,176,176,0,48,240,81,240,81,240,81,
  240,81,240,81,192,213,240,71,224,247,0,45,177,20,1,45,48,132,21,240,86,240,86,240,
  86,240,86,224,86,1,101,98,134,129,240,88,160,62,9,49,57,50,46,49,54,56,46,52,
  46,240,82,240,82,240,82,240,82,240,82,2,62,83,116,130,152,0,97,129,247,128,251,130,
  239,138,33,240,94,160,74,12,48,44,49,32,115,32,40,49,48,32,72,122,41,240,96,240,
  96,240,96,240,96,240,96,6,77,105,110,105,109,117,109,240,94,240,94,176,94,1,48,53,
  144,95,0,50,240,95,240,95,240,95,240,95,240,95,176,95,3,101,101,116,118,130,10,128,
  93,240,90,160,67,4,53,48,32,109,115,240,81,240,81,224,11,228,96,160,7,1,10,60,
  150,78,128,15,199,31,4,32,105,100,61,34,181,135,144,44,8,104,50,62,49,46,32,87,
  97,116,131,128,131,129,228,3,0,63,131,14,0,50,160,34,227,240,192,65,132,136,128,124,
  0,34,244,46,3,32,114,101,103,136,68,4,114,101,101,114,116,147,212,0,97,136,18,2,
  105,116,117,128,10,147,229,0,103,228,72,243,222,243,222,1,111,110,141,234,144,230,5,107,
  101,114,46,32,68,244,17,132,17,5,107,111,112,112,101,108,144,83,1,122,101,192,71,0,
  115,128,71,148,105,132,86,4,32,116,105,106,100,148,11,132,23,3,45,108,111,99,147,194,
  144,15,132,21,128,205,1,105,101,133,90,0,101,144,118,144,47,1,111,112,144,152,132,52,
  0,107,130,18,148,158,180,54,245,101,160,224,152,208,245,95,224,23,244,60,240,25,160,25,
  4,110,117,109,34,62,247,2,160,31,132,66,181,57,0,115,225,6,244,87,145,77,1,62,
  80,134,61,138,139,136,5,128,9,241,44,161,44,149,59,0,97,195,178,225,33,0,115,138,
  68,2,97,97,108,130,106,128,20,6,108,108,105,118,111,108,116,244,246,240,127,240,156,240,
  181,240,181,240,181,128,181,0,50,240,54,192,181,0,82,133,174,162,2,0,119,147,52,240,
  180,240,180,240,180,145,178,2,99,104,105,160,146,2,65,68,67,133,68,5,117,110,116,115,
  46,32,150,10,0,105,198,5,158,162,1,114,111,141,84,149,235,134,110,145,141,144,218,2,
  121,115,101,240,188,240,134,240,163,240,188,240,188,240,188,128,188,0,51,240,54,192,188,0,
  84,146,9,1,38,32,194,4,240,187,160,187,134,48,0,45,146,42,0,44,160,183,130,165,
  150,125,176,17,146,57,186,103,160,167,161,125,2,97,110,116,129,107,5,103,101,118,111,110,
  100,146,77,138,218,129,115,151,4,1,32,119,156,194,0,110,162,123,129,175,145,44,0,100,
  130,172,3,32,116,111,101,144,47,2,101,103,100,240,217,243,139,195,132,240,200,176,225,5,
  108,108,111,117,116,32,136,142,136,42,176,50,195,208,0,71,147,36,2,103,101,107,140,58,
  138,183,145,57,3,32,100,66,45,151,133,148,8,176,36,160,49,131,43,211,75,1,108,101,
  128,219,179,94,162,61,0,111,131,32,2,117,100,105,128,218,162,57,2,46,32,90,144,205,
  8,114,32,97,107,111,101,115,116,105,129,188,1,101,32,176,97,163,52,0,109,130,110,160,
  211,177,251,2,110,32,110,128,240,3,32,97,108,115,128,122,5,40,65,41,32,111,102,160,
  91,7,111,102,102,105,99,105,101,101,145,30,162,225,5,110,105,118,101,97,117,209,23,3,
  103,101,195,175,149,11,140,68,0,116,144,184,163,205,0,114,146,86,208,87,192,41,0,119,
  128,66,1,111,112,136,146,135,189,144,178,128,104,2,109,86,32,140,125,145,132,130,79,144,
  11,0,44,139,2,1,97,114,161,167,133,4,161,154,168,136,129,109,130,88,164,100,1,112,
  112,128,59,0,108,176,153,144,17,192,149,0,115,167,62,5,32,60,101,109,62,65,132,174,
  3,101,102,60,47,128,11,3,32,105,115,46,241,142,129,73,180,202,149,29,245,22,136,43,
  234,126,197,26,6,50,46,32,66,101,110,111,130,214,128,98,208,30,245,25,245,25,245,25,
  133,25,128,249,140,181,198,126,244,208,5,32,98,108,105,106,102,132,155,130,99,4,99,116,
  46,32,65,176,191,128,90,157,68,0,101,129,141,11,117,117,114,45,47,108,117,99,104,116,
  118,111,128,5,143,90,137,88,208,211,145,63,0,116,179,93,245,122,129,249,132,56,161,192,
  144,25,128,76,194,21,244,225,242,120,224,224,173,243,244,234,240,32,241,0,243,125,208,29,
  0,105,131,211,150,158,0,118,131,226,142,37,4,66,111,120,61,34,159,190,1,50,52,128,
  3,2,34,32,102,132,155,131,162,141,112,128,37,0,114,129,17,0,32,128,32,8,53,34,
  32,121,61,34,51,34,32,174,191,2,61,34,49,128,41,128,212,2,103,104,116,128,12,3,
  56,34,32,114,128,36,1,50,34,175,8,1,107,101,131,24,2,117,114,114,143,44,0,67,
  157,24,208,22,190,250,128,47,10,46,56,34,47,62,60,112,97,116,104,32,129,171,5,77,
  56,32,55,104,56,128,6,1,49,49,176,7,1,53,104,128,109,240,73,240,73,240,73,240,
  73,208,19,8,108,105,110,101,99,97,112,61,34,174,77,144,96,0,47,128,224,247,85,209,
  4,248,235,249,226,249,226,215,139,1,115,109,130,146,4,62,68,114,97,97,129,156,3,102,
  105,114,109,145,76,0,44,130,241,152,220,146,222,1,108,111,134,128,0,108,160,54,1,45,
  110,133,107,134,246,129,168,176,55,240,116,244,62,241,129,241,158,241,158,240,29,241,158,241,
  158,241,158,241,158,193,158,225,68,11,53,32,54,104,49,52,118,49,50,72,53,122,241,61,
  241,61,241,61,241,61,241,134,177,134,0,57,177,127,0,51,241,127,240,66,240,66,240,66,
  241,127,241,127,241,127,241,127,240,229,241,127,171,122,0,32,147,78,151,213,9,83,104,105,
  101,108,100,32,86,49,46,250,199,193,132,149,245,0,107,129,110,145,117,167,72,252,47,241,
  112,241,101,240,11,241,83,241,112,241,112,240,29,241,112,241,112,241,112,241,112,241,112,145,
  46,1,49,50,130,168,3,97,52,32,52,128,41,144,2,4,52,45,52,86,55,192,16,8,
  49,32,48,45,56,32,48,118,52,240,32,128,8,1,52,90,241,86,241,86,241,86,241,86,
  241,152,177,218,5,49,49,97,55,32,55,192,73,0,49,128,82,160,126,1,56,118,131,141,
  240,81,240,81,240,81,240,81,241,167,241,167,241,167,241,66,241,167,252,174,249,228,253,194,
  241,166,177,131,220,156,197,187,180,231,154,40,250,19,241,175,240,109,240,11,241,146,241,175,
  241,175,240,29,241,175,241,175,241,175,241,175,241,175,161,69,15,52,32,49,55,32,57,32,
  56,108,52,32,53,32,50,45,51,128,6,1,55,72,241,146,241,65,241,65,241,65,241,65,
  177,65,3,106,111,105,110,241,66,4,60,99,105,114,99,137,30,0,99,128,136,4,49,55,
  34,32,99,133,39,0,54,133,16,245,15,240,95,240,95,240,95,209,241,241,137,240,246,241,
  137,7,62,65,105,114,53,51,48,90,152,234,241,125,177,81,128,19,129,11,17,97,32,83,
  101,114,105,97,108,49,47,85,65,82,84,44,32,122,111,151,144,2,98,105,106,150,75,246,
  197,246,197,241,145,240,117,240,11,241,116,241,145,241,145,240,29,241,145,241,145,241,145,241,
  145,241,145,161,145,15,54,32,51,104,57,108,51,32,51,118,49,53,72,54,86,51,241,139,
  241,44,241,44,241,44,243,29,160,71,0,57,128,65,1,54,104,128,64,240,63,240,63,240,
  63,240,63,241,107,240,235,241,107,177,87,212,103,172,98,241,109,177,45,0,83,172,148,202,
  54,6,115,101,115,115,105,101,115,156,149,145,109,4,67,83,86,45,98,137,152,129,108,1,
  101,110,241,95,240,105,240,11,241,66,241,95,241,95,240,29,241,95,241,95,241,95,241,95,
  241,95,161,24,5,55,32,49,50,104,49,164,41,3,55,118,49,48,241,30,241,30,241,30,
  241,30,242,232,244,41,242,231,242,231,130,218,146,231,144,8,130,232,0,57,240,95,240,95,
  240,95,240,95,241,125,241,9,241,125,177,103,0,51,148,51,1,98,105,140,127,5,110,103,
  115,100,114,97,129,74,241,131,177,81,0,86,153,32,3,51,46,51,86,139,248,1,78,68,
  150,25,221,105,3,117,105,116,103,137,68,0,32,139,44,3,114,32,65,48,241,131,240,111,
  251,208,250,66,250,66,250,66,0,34,140,29,0,115,132,205,138,171,234,68,1,51,46,235,
  169,240,30,250,68,250,68,250,68,138,68,4,83,99,104,97,107,139,42,130,52,216,116,141,
  248,1,108,101,157,97,128,66,170,8,140,127,1,32,106,140,32,3,101,32,98,101,144,245,
  207,25,160,99,171,127,208,120,7,103,101,98,114,117,105,107,116,128,9,128,248,3,73,50,
  67,59,188,237,252,37,0,108,202,95,137,185,1,104,116,129,57,3,101,101,107,115,236,77,
  130,169,1,65,48,138,183,133,168,143,138,146,164,250,91,208,191,2,119,105,114,128,33,218,
  84,2,116,97,98,145,246,224,27,1,101,45,160,18,242,171,4,116,104,101,97,100,208,14,
  144,16,1,114,62,128,20,214,57,1,60,47,128,12,144,16,208,251,0,47,247,245,167,245,
  224,33,2,70,117,110,155,230,176,16,0,47,128,70,208,97,128,17,240,98,128,96,3,98,
  111,100,121,240,112,176,112,0,100,130,28,0,112,141,206,192,168,1,112,105,129,181,2,86,
  67,67,129,221,128,22,144,79,128,33,240,37,240,37,129,211,1,51,86,240,38,176,38,1,
  86,111,129,156,128,161,182,199,176,23,240,145,240,116,240,79,224,79,130,144,240,78,240,116,
  240,37,240,37,240,37,128,4,1,71,101,132,79,0,110,141,207,138,95,0,101,140,92,0,
  107,132,96,128,49,0,97,240,125,240,125,240,125,240,88,160,88,2,79,85,84,240,88,240,
  125,240,37,144,37,0,65,153,98,240,36,128,4,167,188,254,105,162,68,240,120,241,134,241,
  120,128,13,146,4,243,70,242,67,255,22,159,22,0,100,156,209,0,114,255,24,163,198,0,
  78,158,148,130,137,194,193,143,184,0,111,142,243,243,81,255,29,144,54,242,252,130,233,0,
  101,141,116,239,28,243,240,1,46,32,128,251,142,253,128,88,211,250,3,32,83,68,65,148,
  26,2,83,67,76,222,174,173,112,0,100,130,247,193,217,191,29,211,81,254,85,160,205,3,
  104,51,62,79,132,137,0,105,128,101,175,114,0,100,131,49,147,235,0,51,179,235,158,25,
  138,154,160,98,198,41,174,20,0,118,158,197,0,112,163,147,250,225,250,225,156,39,131,118,
  144,213,247,208,0,83,222,78,129,3,159,76,0,111,159,30,247,190,247,190,247,190,158,131,
  207,135,132,64,135,251,5,60,99,111,100,101,62,200,1,1,60,47,160,14,161,30,243,232,
  244,235,244,235,196,235,3,115,111,102,116,255,45,132,207,3,52,46,32,70,204,245,132,45,
  128,127,132,175,133,216,244,235,244,235,244,235,132,235,0,71,177,77,144,180,254,217,221,63,
  164,237,128,26,160,196,5,97,98,45,114,101,112,130,111,3,116,111,114,121,145,17,129,151,
  154,44,0,105,149,2,0,118,133,14,2,122,111,119,181,52,177,173,138,76,165,20,129,21,
  128,20,213,64,0,101,205,146,244,200,2,112,114,101,172,91,128,97,7,47,10,226,148,148,
  226,148,128,128,3,1,32,77,132,123,11,114,95,70,117,116,117,114,67,105,116,121,95,133,
  112,146,66,129,72,1,115,47,162,103,240,43,241,99,0,95,192,196,1,95,49,176,36,240,
  40,240,40,240,40,144,40,0,46,128,103,128,139,128,132,243,18,177,41,6,103,114,105,100,
  32,116,119,129,36,247,254,227,45,1,114,100,245,79,240,25,5,34,110,117,109,34,62,129,
  206,247,43,162,152,213,74,2,73,68,69,210,145,160,27,3,112,62,79,112,130,21,178,11,
  240,158,240,158,176,158,160,31,2,44,32,107,152,184,255,4,239,4,146,88,0,115,130,54,
  2,99,116,101,130,101,129,108,2,106,117,105,139,194,3,32,67,79,77,179,170,177,108,180,
  7,247,86,240,183,240,208,240,25,240,208,1,62,50,240,54,192,208,4,85,112,108,111,97,
  134,8,240,203,128,203,176,21,162,0,4,107,101,116,99,104,131,227,144,221,147,6,1,110,
  97,144,23,178,236,3,32,77,111,110,146,67,147,117,212,96,7,49,49,53,50,48,48,32,
  98,132,208,228,75,240,181,248,0,243,237,240,164,228,186,2,103,111,111,208,197,208,88,211,
  18,137,144,5,102,105,103,117,114,97,166,174,244,172,164,172,0,104,140,255,146,152,226,245,
  231,177,177,152,149,127,179,158,196,143,212,222,0,44,164,217,3,49,50,45,98,131,38,1,
  65,68,164,91,144,18,154,103,132,86,157,69,1,32,118,133,204,6,53,48,32,109,115,32,
  112,128,14,205,108,179,26,2,46,32,72,132,116,244,41,191,35,131,151,2,101,114,118,129,
  39,7,105,115,32,48,44,49,32,115,164,123,0,107,129,198,145,211,147,218,2,101,108,98,
  179,229,240,41,6,48,44,48,53,32,115,59,161,108,148,129,197,151,144,172,176,125,240,147,
  0,114,131,142,136,19,0,99,181,208,0,108,149,8,148,198,131,189,149,52,5,32,101,120,
  116,114,97,168,110,144,105,128,64,1,119,97,136,148,3,116,105,106,100,245,110,244,150,244,
  150,201,129,1,112,112,228,145,3,53,46,32,86,186,23,161,19,164,72,179,251,228,148,241,
  197,4,34,102,108,111,119,243,105,240,23,128,23,0,45,128,138,128,87,0,49,129,9,245,
  75,129,9,185,164,148,227,242,212,240,59,240,59,130,193,0,46,179,40,0,111,130,144,240,
  48,240,48,240,48,176,48,138,53,195,103,0,45,176,111,2,45,48,49,147,126,133,151,240,
  61,240,61,240,61,144,61,133,137,176,53,4,50,48,50,54,33,128,169,1,118,111,181,137,
  240,57,240,57,240,57,0,34,145,49,10,49,57,50,46,49,54,56,46,52,46,49,240,173,
  242,252,246,233,5,83,116,97,116,117,115,128,93,241,86,246,234,2,62,79,109,144,23,194,
  199,129,45,145,191,129,253,162,157,242,131,149,157,167,80,2,97,102,32,130,91,2,108,101,
  105,209,170,1,115,110,133,200,2,119,105,115,148,85,129,191,3,32,114,117,119,146,9,130,
  165,7,101,110,44,32,116,111,111,110,161,206,128,117,215,58,5,100,97,115,104,98,111,146,
  198,147,36,130,149,221,110,160,168,162,195,192,121,192,71,4,32,122,101,108,102,231,128,235,
  93,141,139,4,99,104,105,107,98,146,150,176,221,253,161,144,54,144,193,4,114,97,102,105,
  101,151,148,196,33,241,79,162,129,0,45,133,204,157,118,242,78,224,30,1,116,105,139,24,
  6,112,114,105,109,97,114,121,244,239,240,33,5,34,108,97,98,101,108,151,20,160,171,218,
  77,244,253,240,45,128,45,131,124,0,117,135,128,0,65,155,3,0,102,240,38,240,38,183,
  111,2,117,98,34,219,90,2,32,194,183,241,22,0,115,240,51,244,226,240,60,224,176,3,
  100,97,114,107,240,173,240,30,224,173,136,142,240,81,240,132,240,42,208,170,1,83,97,131,
  211,0,108,185,66,0,118,147,239,242,94,240,50,240,182,5,62,111,102,58,32,71,146,52,
  0,115,240,57,240,57,240,188,240,11,240,66,160,188,240,183,240,25,208,183,255,173,240,131,
  240,40,240,181,0,71,131,61,0,101,134,22,240,38,240,38,208,169,255,216,201,96,1,111,
  112,153,150,1,97,103,240,169,240,169,240,66,240,169,240,169,240,25,208,169,0,84,131,61,
  240,59,240,36,240,165,1,34,62,138,88,240,35,240,35,240,162,147,130,131,230,0,109,140,
  42,166,9,179,127,240,52,240,157,245,99,245,99,245,99,1,61,34,128,58,254,223,4,62,
  54,46,32,69,179,181,147,206,133,245,212,109,245,98,248,207,0,105,231,31,240,23,247,251,
  240,25,247,251,248,203,176,31,132,98,0,67,131,253,2,114,111,108,200,106,210,121,248,9,
  132,127,240,35,6,32,118,195,179,195,179,114,164,35,128,43,0,114,150,148,1,111,102,180,
  157,243,99,134,129,138,36,215,180,211,80,192,15,193,210,0,119,128,78,1,103,101,130,127,
  148,130,152,76,219,195,133,105,130,32,151,5,128,92,134,109,0,105,128,7,1,110,111,148,
  76,146,186,131,29,0,45,242,190,128,37,210,193,248,94,240,226,240,255,241,24,241,24,241,
  24,249,19,241,24,149,146,128,142,170,253,146,137,241,19,181,146,169,231,192,211,0,77,145,
  195,224,225,201,216,145,35,2,103,101,119,167,164,164,37,231,224,151,200,2,114,117,107,249,
  48,9,103,62,83,84,65,82,84,32,77,69,160,4,1,69,78,249,52,1,32,66,213,65,
  248,34,133,91,133,111,2,105,106,110,200,39,0,44,184,88,144,7,0,50,192,15,160,7,
  160,20,1,50,32,161,73,128,17,141,144,232,155,129,188,139,224,252,32,128,139,184,156,241,
  70,241,16,241,45,241,70,241,70,241,70,135,104,240,54,225,70,128,91,0,38,174,45,1,
  121,115,129,243,241,71,161,71,160,31,225,100,250,97,154,97,173,189,130,93,0,71,214,32,
  1,32,111,167,7,244,12,161,87,130,46,1,107,115,150,240,2,98,101,107,159,181,242,10,
  240,196,247,108,144,148,0,77,128,54,134,53,3,110,99,105,112,225,215,240,203,248,187,240,
  226,247,218,183,218,1,65,48,183,83,3,98,101,109,111,169,132,244,152,240,53,240,53,200,
  15,249,185,185,185,240,51,240,51,240,51,144,51,6,109,105,110,105,109,117,109,129,65,2,
  109,97,120,160,10,3,98,101,112,97,249,35,240,59,240,59,192,59,0,112,129,51,4,45,
  116,111,116,45,144,9,128,55,0,114,145,66,240,57,240,57,240,57,176,57,234,77,129,100,
  138,71,135,181,135,178,241,74,244,206,244,206,244,206,0,34,157,213,228,205,0,55,145,209,
  225,173,144,27,254,190,229,78,254,190,158,190,1,73,101,138,181,200,107,246,1,136,211,132,
  81,1,97,102,186,212,136,100,0,107,248,71,0,110,155,105,208,101,0,46,242,212,251,246,
  190,173,128,30,128,9,8,107,111,108,111,109,109,101,110,58,254,174,128,111,210,221,1,115,
  118,150,124,4,97,115,117,114,101,128,36,8,116,95,105,100,44,10,114,116,99,158,171,131,
  192,4,109,101,95,108,111,140,157,25,44,10,101,108,97,112,115,101,100,95,109,115,44,10,
  115,111,117,110,100,95,112,50,112,95,109,86,240,14,4,112,95,97,100,99,208,15,4,98,
  105,97,115,95,128,29,0,108,140,175,3,116,117,100,101,128,10,131,221,192,11,196,206,1,
  116,101,128,76,6,103,112,115,95,102,105,120,176,9,1,115,112,133,8,3,95,107,109,104,
  176,15,1,117,116,128,80,144,128,145,47,0,95,128,89,1,114,99,130,190,254,232,241,205,
  205,64,253,59,164,75,227,71,253,48,144,31,137,201,241,63,213,198,2,97,109,112,128,146,
  128,159,193,126,134,136,0,103,139,45,0,116,131,103,161,202,129,81,140,120,131,123,147,150,
  172,76,172,251,1,122,105,140,91,164,170,221,46,133,161,0,50,131,44,157,176,153,238,0,
  98,165,219,154,146,149,204,144,57,1,45,97,189,73,132,160,192,37,132,243,140,241,1,108,
  97,140,178,162,9,151,9,128,45,4,107,117,110,32,106,141,220,2,111,114,105,130,6,132,
  191,138,147,205,190,202,65,2,32,115,119,131,209,166,144,1,115,99,134,175,131,39,170,168,
  0,121,144,100,154,153,0,102,154,215,189,80,2,118,97,115,166,193,0,97,134,125,1,122,
  111,129,223,164,133,140,129,128,87,1,97,108,144,153,139,63,1,101,115,170,183,192,59,144,
  132,141,181,230,234,147,88,150,155,150,136,145,38,169,87,130,54,1,103,101,149,221,0,116,
  253,94,243,45,243,45,179,45,192,185,227,48,1,56,46,212,237,235,236,247,250,243,50,243,
  50,147,50,242,241,129,109,145,44,0,114,145,134,149,44,240,175,240,175,2,111,111,107,236,
  62,209,100,179,105,0,115,209,191,128,243,128,55,1,104,111,129,255,251,147,242,95,168,120,
  2,32,116,119,128,123,244,71,246,30,134,30,240,18,248,117,145,9,149,124,242,14,0,110,
  161,248,229,11,128,28,134,16,129,175,0,120,145,175,188,147,128,26,3,101,100,115,32,130,
  172,136,39,128,45,240,61,181,251,178,122,153,208,140,1,141,24,178,42,161,215,1,32,105,
  180,73,242,88,160,203,244,255,240,184,240,184,240,18,248,21,192,184,0,72,242,120,226,94,
  224,181,1,117,117,184,42,201,182,177,88,130,108,0,110,240,178,152,230,162,160,242,159,160,
  33,0,110,145,111,133,113,1,104,116,189,85,144,215,130,112,0,110,195,121,162,94,194,87,
  129,47,1,115,116,240,198,240,198,240,198,240,198,240,198,215,149,144,198,0,86,130,247,179,
  17,241,113,210,247,2,108,105,110,135,72,194,237,135,150,168,97,0,112,134,4,0,116,129,
  143,194,50,243,126,241,6,211,65,228,52,133,169,179,66,1,97,102,243,68,190,24,240,190,
  240,190,240,190,240,190,240,190,1,62,52,240,190,0,80,178,195,1,98,101,178,156,208,195,
  1,79,109,195,192,212,80,132,102,129,252,193,66,147,238,242,233,178,233,222,166,179,33,195,
  26,242,254,134,243,192,248,0,118,129,162,161,126,147,18,185,121,240,195,247,15,243,226,243,
  226,179,226,129,251,171,58,227,227,2,57,46,32,219,78,219,76,195,235,251,227,241,2,7,
  99,104,101,99,107,108,105,115,229,204,240,28,176,28,241,49,144,19,2,98,111,120,128,17,
  177,48,144,5,18,65,114,100,117,105,110,111,32,85,78,79,32,82,52,32,87,105,70,105,
  148,199,169,89,3,76,111,103,103,146,173,9,83,104,105,101,108,100,32,99,111,114,167,247,
  0,103,152,210,131,119,1,114,100,128,233,160,73,241,174,240,107,240,126,240,19,240,126,192,
  126,1,109,105,130,34,251,215,0,101,177,84,146,194,240,88,240,88,240,88,240,88,240,88,
  240,88,0,118,239,124,3,86,67,67,32,131,234,150,188,0,111,172,136,5,112,32,51,46,
  51,86,240,96,240,96,240,77,240,96,240,96,240,96,240,96,128,96,2,71,78,68,240,96,
  176,96,128,19,240,95,240,95,240,76,240,95,240,95,240,95,240,95,128,95,2,79,85,84,
  240,95,176,95,1,65,48,240,94,240,94,240,75,240,94,240,94,240,94,177,243,5,105,114,
  53,51,48,90,157,40,240,94,162,182,240,88,240,88,240,88,240,88,240,88,240,88,0,118,
  246,102,5,32,102,105,114,109,119,151,228,7,103,101,195,188,112,108,111,97,242,42,240,93,
  240,74,240,93,240,19,240,93,176,93,0,83,133,187,132,82,4,77,111,110,105,116,135,211,
  149,199,132,168,130,150,129,20,9,49,49,53,50,48,48,32,98,97,117,240,104,240,104,240,
  85,240,104,240,19,240,104,176,104,3,86,101,114,98,214,62,1,116,32,195,30,0,45,147,
  10,4,101,114,45,48,49,240,96,240,96,240,77,240,96,240,96,240,96,160,96,133,77,5,
  119,101,98,97,112,112,198,192,255,23,255,23,255,23,255,23,173,234,240,125,240,125,240,125,
  240,125,240,125,240,125,161,69,237,221,254,109,149,167,173,234,221,224,0,59,206,51,152,44,
  139,62,190,90,132,243,0,118,201,75,3,104,111,111,103,150,35,149,75,6,115,114,101,115,
  111,108,117,128,166,240,156,176,156,244,246,244,246,244,246,6,61,34,112,114,111,98,108,155,
  66,228,247,4,49,48,46,32,80,208,22,128,142,1,108,111,145,19,180,243,244,244,248,95,
  248,95,240,27,254,125,160,1,150,18,0,71,241,94,128,192,167,45,0,97,193,87,254,103,
  134,35,213,115,134,22,128,4,137,251,147,125,2,226,134,146,131,114,0,44,222,111,148,60,
  149,30,147,228,151,138,193,202,2,104,111,101,135,16,0,103,154,176,3,108,105,118,101,246,
  231,150,19,1,116,111,141,83,0,59,170,60,3,116,97,116,117,141,222,0,111,154,14,142,
  26,241,230,241,230,128,15,202,42,254,163,241,240,240,234,240,234,240,234,0,87,176,142,0,
  111,138,225,184,22,240,226,240,226,176,226,136,97,139,41,139,161,194,236,0,98,144,51,146,
  241,224,148,242,249,178,249,240,159,161,157,128,5,208,43,9,49,57,50,46,49,54,56,46,
  52,46,240,37,240,189,240,189,240,189,240,189,240,189,1,83,68,177,156,242,114,185,241,240,
  191,0,83,136,132,0,107,129,55,129,74,150,158,176,154,156,119,0,44,215,139,153,95,182,
  81,157,205,4,108,101,100,105,103,144,174,129,120,134,93,1,111,112,128,96,1,117,119,240,
  154,240,154,240,154,240,154,240,154,0,71,145,216,205,130,128,161,138,104,161,52,240,158,160,
  158,1,71,97,185,168,0,98,128,145,188,97,160,15,144,60,1,112,108,139,173,145,93,1,
  118,114,136,105,168,68,147,109,128,174,1,108,117,144,12,173,84,1,101,102,144,17,149,147,
  169,24,139,155,224,115,200,91,0,105,188,250,4,90,111,100,114,97,160,88,132,56,128,226,
  136,157,2,111,115,105,130,66,241,59,152,160,136,153,1,101,114,131,238,0,101,218,119,128,
  44,135,203,160,149,209,186,0,83,240,213,224,213,241,193,241,39,243,210,128,9,243,139,254,
  73,0,117,130,209,131,33,254,78,160,68,0,87,148,106,128,229,143,139,0,116,136,61,139,
  197,0,97,130,102,129,26,1,101,120,142,23,1,101,109,254,101,144,54,242,158,144,176,134,
  152,0,115,131,184,171,44,153,98,1,65,48,145,39,128,25,208,237,144,21,149,60,1,97,
  105,156,230,150,11,138,157,0,103,193,88,199,64,2,46,32,69,128,53,129,8,0,107,152,
  173,171,87,0,122,144,96,1,104,111,129,54,144,58,1,32,107,128,70,0,104,155,63,1,
  105,103,129,26,138,225,129,18,0,110,128,219,1,105,112,130,226,253,159,244,199,148,199,237,
  102,129,212,0,97,253,93,5,49,32,194,183,32,77,131,53,10,114,32,70,117,116,117,114,
  67,105,116,121,144,19,162,173,1,97,98,144,11,0,72,128,121,129,164,128,49,176,213,0,
  109,156,216,1,100,97,129,10,129,109,2,60,47,109,128,147,144,97,1,102,111,135,144,0,
  114,208,102,176,14,181,39,193,49,192,83,243,148,128,92,240,135,208,116,163,33,128,87,176,
  65,165,129,10,99,114,105,112,116,62,10,40,102,117,110,160,207,2,40,41,123,128,87,2,
  116,114,121,144,7,28,32,32,105,102,40,110,101,119,32,85,82,76,83,101,97,114,99,104,
  80,97,114,97,109,115,40,108,111,99,97,144,46,1,46,115,160,22,7,41,46,103,101,116,
  40,39,112,141,76,8,116,39,41,61,61,61,39,49,39,160,72,144,1,0,119,130,167,6,
  111,119,46,97,100,100,69,139,63,1,116,76,138,153,5,101,110,101,114,40,39,152,6,1,
  39,44,240,121,7,123,115,101,116,84,105,109,101,130,61,240,143,1,41,123,192,64,160,93,
  10,40,41,125,44,51,48,48,41,125,41,59,160,94,0,125,128,6,0,125,128,139,10,99,
  104,40,101,41,123,125,10,125,41,40,128,26,129,6,192,215,5,60,47,98,111,100,121,144,
  8,4,104,116,109,108,62
};

static const char INDEX_HTML[] = R"DATALOGGER(
<!doctype html><html lang="nl"><head><meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1,viewport-fit=cover"><meta name="theme-color" id="browserThemeColor" content="#343F58"><meta name="application-name" content="DataLogger"><meta name="apple-mobile-web-app-title" content="DataLogger"><meta name="apple-mobile-web-app-capable" content="yes"><link rel="icon" type="image/png" sizes="32x32" href="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAACAAAAAgCAYAAABzenr0AAAGFUlEQVR4nG2Xy4tlVxXGf2vtfapuVdftesRGJGAEEeIrdoxBMHaUDIwECYRMpBASRFFwJoKDoGOH+Qt0YCYZiYIBdaQhCopkYGvnYaM0+EijIklV3dfZaznYj7Nvtxcu99xzz17Pb33ru3L12qm7gDjg4AIi+Zr+k3wtAr51r/8y/S4iOJ7vFTOTrfoQqOPFCLRrpx1up8s998locyvbjyLdecDveqBECqj0psRzBi253kg1k0vkxYiIlsy8NzOd9e7dl7J85ApIjVNacNWZu5f+lFAll1dqGYt1mWLNMZYEpNhumUn3mAjaHZsC9epwsiq1Bp6DUhVUFWmGpQU5lb+3sJ1krWqsnr2hREsPqWjKyCy1raEtFisWqyUqMD84QFQxM6SWXqRURbayrv5EwByiVD90iXR5S3dCUETg/OKcBz70Ab7w+c/y2ht/5aWf/QpCQFEMK5MgVPh5s1GAzATi2P8o3eP8v2BUWS4X3Pfee3n+e9/m6HDObLbD0eGc77/wE+bzPTx1Cau0qbqzBU7Gh/aOGqS8Q3xXRVVhuVrz4AP3c3j5gLdu/4eLiyWPPvJxNAgpGYIQYiQOkRjCRCoTgreSilujWeMU2b4BZbZAJDQjOzsRVUgpZSuecJSz8wvchZ2dgWEIJLeu/ZVHMqzjnc57+pOetRxEMvpjCAwxoColOUdwUkqEAZ49fZL3vPtdvPTzV/jDjTfZHSJWAd27AKJsw6QFUp2HkIlmTBvcFVElhkAIWpDsuEMMymK15LlvfIVnTp8E4PHHPsmXvv4d/vb32+zu7N7Bjo2K+1dBbumbirBcbHj7nTPSmLrgpLXWLJtNZhxenvPopx7i7GzBP2//m3tODvno/e9nsVihqlusmGkfIjhtGfW0IcpyveLhhz7ClZNjXv7N71gs1miIrZT5SAaeoAzD0KhDRVmvE6P1/b+bEhoPVGBARvv5+YIvPv04z33zywjCb1+9zre++zzL/54jXpZSYUxVIYRIiJEQtRBbTrVOoRecbK1Y78aw7Qpx3JxhiDz1xGdYrzf8461/8fDHPsgnrn6Yd84ucDdSsrInMk40RoIGAKw4zqOrZW9QaLyygeNSqLjum0oO7k5QxcxJyQgxYO7szWaklEhmmHkDqaigZUOaOZYy36lqeyPZYc2zVkLv0h0+9VdkejTGkIMzwy0VmEjL0N1xM8ysrWJVJYRYGBHEy8x1Lde62zOqG86b835CpoAEFd0SJW6GpdRao6JoyJXJbgrSRbYSU2kKqJ+BSVy453JWIpFS0j4+d8dsJKURS5Z3qlZZVtmv4/uOkbVHfxUP7pn9fIIwZgkRIYSBEGLLIpfcMMt0LJKzrg7dra1bl07Kef6uxeWWoqkoGJOVma7GIOhAiLGBdRwTlqqOEERlYsnSlqmoUph9KkFWRDJRcdVjZhCC5tK3oPICGWKuwGYzsl5v8k4gV2e2u5PPt9ZKJ806jVMarlVKtWlwR4OwWCx5/eYtjo7m3HNyyGq15o+v3WR/b4frN24ypsTJ8WWOj+Zcv/Fn1usNZ+cr3vzLLeYH+5wczXn77II/vX6T3Z0Bs6IFmq4vVbl67dR9ooYclSrjuGF/NuOrzzzF++67lxd/9At++crvOT464vxiyWOffpAnPvcIb9y8xQ9e+DGWHI0DJ8dzvvbs01y5cswPX/wpL//6VeaX9spoToqx4e7qtdOpxj79KAKbMbFYrRFVxBKX9vdAlDgMnJ9dsFqvSOPI/GCPYRgIYSCZsFguMyh95ODSpZx9Zdtu0IAiSoVGHiLSrocYmM3mAKRxzKJTnDRuONifsb834OZlJQtmiaCRy/N9LI2Zsq1XVyW9wroudRv6JJYbEMt1Gsd8zwxqcO6MZdmYS8FtDWLETHCsEJsUfvPmoZOIRYN3OKfowUkXFjKqf0bavYxhLQzqaLcBrfe3rbYqDZdpU8S7BypJ5FI5Wbt3P9AU6tarC8wqd8nkXArImzaUlqDigtS/xl0bqj8pLemFW21QE5hSdeHEdmX7lKemHVLjrx4nDHTjKYVSvU6Flwy6w32k0xqfAJY5V7YqmjFkWxH8D13zZ1pmMqQiAAAAAElFTkSuQmCC"><link rel="apple-touch-icon" sizes="180x180" href="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAALQAAAC0CAYAAAA9zQYyAABGpklEQVR4nO29aZsct7Em+gKZWVt3s8nmLlFctMuWLdsz9jw+z5y5/2N+79yZ63PGtmzLWqyFmyjuW6+VlZmI+wFbYMmq6pYoNakKPsWuykQCkUjgxRuBAFJ89O//kwBAwIj5Qux/4c+akxQmdsftFf4MRUmin+EBsnnoXKSU7BS54yCmk2DX8qyEPiVYIndPUdo4q+iWFhzI5xWmpbAc8gXGSZYTmx+/O3Z2ibyECK+iWAHB6pj0WQpvg9WbrV/KFL6oAfBTeZ2ScrP56S8yl2YlK3lZpcwBnEc2C5oGqef1/BA05kDbnC6awGx0WkR/s2n67gQLoWuuhj3olB2s+oqJh6uMCIQVmFzixlNapPH3E5Y1G1CCe5uLmH33upTKhxqugmtWCL2SV0pKz5O1EITvRGSwQHAOyiSHeDGSLaBUyaUcUGPuyUlnHwBwZGGcOyzH3HNM75J0PkGvTSBcYf4uem6eiIKjevwQQb7+irAgkeQvXOqUtkaVFA9ayHDmOBMhDCfO5dOPoMS+CQBCyKC8+Jkk9pkpe85PZO0gIyuEXskrJaX9EvcsfkxEQNdLk5ahPiE8HV7ia/pQdgldFnsDKC0gO0IQqzXBx7isqh6tmFngwHBJOwLofQDJJaFBlFMtdyCjRGjE5KrPjRsiW3tsRMqMnku0B27D5MpfIfRKXikpYzzOOyl6/NFHkdgbkKNQy+RzJKQ5pMzzXETlc56XqJan8hqMLT1dMNrFo2VWTaZEdvB5Ac6QRH4Ax8sSzrTe8lYIvZJXSsp+9KXk2+JO18eq0hTR3J3RILT4E92O4J4knkdM/kXoX0+sB9InBSP8MQ9OS0KQTheXOq0Fc+p6Lk/+3u0sYOJZYDnH3idmFMyfVfMeFz/ChC0ga19kqic4bMizyFzjni0tM9rHrrJIDTacxc9hhdAreaWkTBA06OX91mwovEdFnNwhQZiXY+zkj/TxI4qR+rD8zPqkTc9O/Zo2Wb/JTVHRQfxCdKzX85JMowrv5rXoRhSliYVMPlzbnrRxcblkDGbT0/NdEDGfz9pftPzjiucdvIGxjMtK/1kh9EpeKSn7es+hQDCGr+DH4Ynv0a9kKvX+yGU8724X1UTGyZutj1i4V0ksDvM4jOmfKf5oddnjg39REnu9jlDeCqFX8kpJmczPc/7ieFXsSM1xm9AL0Csi+prz0Ubl5IDfU/M+HwzLcUGvF9GsFY/h0KghUt491/sQF5ArW1duXKVpYofhVll/PtHBXpH3LOV+xbaNiJ5ptup6BiCiXPXG9xF6rDKWU0YyxgBF+a380Ct5FaX0iJdDGPIGODtxKK9DHDnlcg4pUy6LFNgyEECpt0EXG6JsOAKw0YgXHLqnTfZkwFSfXIwAWZjqSclqdsE1npbb/JnyfaMHr9wej0SsS3CpyD+jOGrQZ5rxLkfVkQxEGRHumdrybPai93qbdoXQK3mlpEyQLfA9hxw2t+4slj6gOZTxehj3YwTjfA7JHRGWr8dwMd+fEvkhQuWWcMX0sfvcNX2uap9HDtKO4nYIC1iGw0Ze8+/nhlrGfZbkn6tJq3+Y4QqhV/JKSTJT+KKE2ArlDKWLEoc/l0L35DZy3oIF95rzuPSolvBKVm68KqPf8s/ln7Ho3XHhuG0uv5zXIVdCKHmvio7wDh3DR3ND95WXkb5TfV6jTPYrhF7JKyUu2i7b6nuCHvo6iID2YzojnKNij890qR5LIf75XLgnIybTcQqDOcz5LZ3rIOTFSTQXpcjsr/GEv28NI7JegZyVwqst8iUzu0Ik18a8OJLAbROUtHCBzDzJPcm4bfTaESBj24gkcWLXsUwIxlfeY/+sEHolr5SUQuhm73yLOffm0chTkMfhssgjHcXHRHKWnWIl94wOfR6e+VTb1FPmhgTziVNQbr78/uN9CpBDKY9o1Bs9OF/yhoofwCIndEbCMG8/doajzvLK9XtcohEMAnY3J3+tlhVCv3DhA+9KXrSUi5Okwv2SMQdM6OPCvAhp7EEPJ5y3yZmIrzE8c44Ccb/vUTCrWx4V0yGFABMrQn2pGPdkmfbOsNL36yOLADM7Aoa++JSj5z0lC2Xpe4g94f11eaQGvZJUiMgYKwAg9AYrknVNvpDB2TQ/jsv05ySlpj/BfkkuriOmUPFWCryfOMbkOF7Pw0p2zGTegQinYmQW7PqUnsacMO8lEIyI94Utp7sKse8y4uG2TsjCptBxJEJASKMrKUApEJFORy4lSOiPRWlpNXL3ySo9Qk+/B0k0ciUOH5G7SV4heWAm/mT9iXglk+A/ALPnRojqqaTtQ5Dw9gfg4nGSnVKDLIMHu0Low0vsAtMNWMoCUuhWpkAgRVDKPBrSzUIKASELEAHKGOIhaAj2WclRpBSBhWol5CzLVK9LR/n0/SsyMifsIdWPugt1ssAWJxT+YLzWL2BmEWQ5BCaXiaMOQhYoywpFUQAgdF2DRjVQpHQaAopCoCgkClFAAWg7hbZrGbpaZJeB/lo3k4kwaBujK3dSZ6uC+h9A5L8PY1YEr675YhLaNpCsDySeMNLt0JJpB0bJFUIvlKhL2xYqBAopIYQEgVDXNbquQ9e1UKp16EsECKXzEVJfU5QlZFFCFBKFTeRKS43klSwvmWg7LzFX7vMs8nRLPwrWc4/mq47zi1FqscUd287egLNnyX03WAUFBRAgZYGiLCCERDNrMD04wMH+PjrVYFBVGI6GKMsKAgJdpzCbzVBPWyhSKKsKa5MxRoMxSiGgOoVOKShSuhwh/e3ECuf4Y3KvOT/KcnLYZxBz7/j6Q/o9vresEHpJsdsxSrYcazaboWlaNLMGggibGxOc2FzD1smT2NjcwHA4BEigbVrs7x/g+c4enm1vY3f/AM2sASmFQVmhLEtIKfWGjcy4jBRYyRJSWgs42A2SLHe2FnDGqmXCwTGp9xyHtbkROzDXt7zE8SVAKd1LYxHCCcefiTpICBTSGnYK9XSKuq5RFiUunD+Hd96+ivfevorXXzuP9Y11VMMKpBTapsXBQY0nT5/j1rf38OXXN3Dr5h08f74N1XQYTyaoqgpCCCil0JEKeStDZr4DVDC6sq+5ffb83cUdJbx33g68Z7EHd10a/wx7dwvJGlbhORJRm5greftqhdALxbqQjPtICrRti9lshrZtcWJ9HW9cuohff/g+fvOrD/D2m1dw9uwpVIMBikJCkULXdGibDtu7e7j/4DGuXLqIv3/yBb744is8ePgE0+kUXddhOBxCSAlJjvD8tLf+EkrpQYmTWms96yPx/IxHj7DPOx90ID3oR+j5PZ93cZ8kUYo/QSbOAxYSUhF5Nfh8Z0hTtfsNgiBlASEBRYSpMQBPndzEh++/iz/8/tf43Ucf4PIbFzEeDU1DNgpQAVWUoCFhMh7iwrktXL18EdeuvI7/7+wW/u9f/oGbt7/DtK4BKTEYVPp6RToPB1rsHiJvhogjDXNegKTOYh+vtSP4iBlUovcPR3lyP3i4goSSnbN636AGJB6XuFx7zE9K8eP6+wqhF4rlzhJt16JuNDJvbm7gF++/g//nv/8Bf/j9r3D18msYDiUOpjPUdY2m7QAFuAYhgFJKbKxNcOrUBFsnT2A8HgICaLsON+/cRT2rAQGMhyPt0wbQkfoJ7/3lkxIRpoZ9MkSsmLrm/Alpv4t9vDlZzs+R88DER/L78eX9L9kRwPynzI0LqRFBEaGuG9RNgxOTCT5490389z/+Dn/8bx/hjUvnUUiB/f0ataEiRKQbtBAAJIgIDSnsTw8wogFObo7w6w/fQasUmrbDrFO4e+8BZtMZqmKAUhYQUur4ckW2T7g7OyoZ6WWnycONn+5yGXs/dCTRQJybQewfV5aXFUL3iq5wKU1jbFvUsxkKKXH+3Bn86hfv4be/eg9vXDqHQVng2fYu9g8O9KWCIIVkT8+GkxJ2ZjNMD6Y4fXoTJ0+M8eH7b2L7+Q4eP3mOvd19PH26g3o2A1W6UevJ8O6nqICXUlyD9hhpp2s12gl4DpNEulouylZkpH0r5FBB2AHn0ct0yqi8fBqbZWwxM7M92vchXN2iG57lfoUoMFMdZrMZiAgnT2zgrWuX8Yv33sKl186hKiTqWY22mYEIKKTxI7Oi7WwiCOjQousUptMa1XqJM6dP4IN3r+LOnft4+OAJ9vZnmM1mAATKooAQulPpWceIoeYN/dRxZEabeaNtWo8iLaAPdpEaTzHDzXvM+BRS/47b4W5LlN4oy3EVDz1HbHV1nULTtqiKAufPbOHNK5fwxqULWFsbYzqdYnd3D03bOj91ISWkkJDSfwohURQFpCxAAPYPptjb34cUwPmzW3jrzcu4/Mbr2NhYg+oITdNCKcOfV09paZGW+BKZDsm7sLVnRL/rN+XcIvyYaDJfALtW+DzcjDJluDhXYOHbYPW/vM7eQAs+XH+jpjSxFZ0idG0L6giT0QgXzp/BG5fO48yZkxgMKnRdh6ZpARImOMlnKEwewr7zDwQpgaKQIEWYzRoAhPX1MS5ePIvXL13AqZObKMtSzx52io2O5AYdcvWgP75YfUP2X/AApTD2gAg8RVzH4MPPRfUWeoJ4S/D1T/xBRqr4Dx+ZRSa3xeLT6gJWfb9PpASkhFIKbaeRcjIZ4/Spk9g6tYnRcABFhKbtoJSCkAJSLhrHCVJKlKVmem3bYTZrIaXA5uYazp87ha1TJzAaDvR5xVB6JUsJ25eDV1zIMS2H8Z3J/M6sZk79FZHP1B3NXLWgPVCE3vN6cZ+3JuDuc8qzKKaIdIyFFBgNh9jYWMPG2hiDUjuIOkVQAKSh5jx/YgVKaRFPY0gnBLpOh5hKKbAxGWHr1Do2N9cwGFbYPThA23VmZlIjjxIm3JTZIXZ04/czL7gpHrWECOve2xVgdkicSeSy4GVb+4QrCriIwDhGJadpr7cjkzg+tPJyLBAd3QwIKVFUJarKhoniyOgphe1qxiVnjMlBVeqJldLnr+IQ2u8l85pPXE5s1r0ckvFyeFk8gKY/CNZnGqN8KLlOnkrMm5fF5wUSmP/2Z6IhK4M0ukoBWQrIQuiwZbNWkAggBetyDrmh5dKR9mEgEhxXtatdFBGkMnyUKLRvkhoIa9mPTh59+Z2GtxkeC20XCRJ+lU0I36xcdlEYE5Qvsl/cmJPTBuH9hV4Tm3LFoZcQXkmEkJzNlUM8TLuKRamc3cuXqf1gRb6S4nfwz/XUBev3lqk8H2eg+KURmerpkVkL2PdJM2izfPov9X2fGAfNc3fuNXBeAfLM1P+VLI2/zu3jR+wNh85JYLwGwnqBtGvHGpXCknBB0CsDFHSXYjfI9Cd+j4JYWbm9lFPITHYUtSkz9Dl+3sS/8KqMQDq8Nh4Pc/7n8JrEJuC6RWsiVxx6oXCikD8vYDrAC4XHRc0rf6b/daC2c4sXrPePK6Vb+Rw5ObyvE6lpnJOFSUTuj560W2rRmpcAZwKEj8ub9+bB+eJnpwSUm1n0PNcjcuzD9QXxCS2LnM7RDnIwqH3fSq8OJ2If4WHOce7QgyOMjjqB3rtPwqA/X4Qr8g3dVp80iZIIS76GkV0d1Cj3ZrDDtv7myVEsoXn0a4XQL0A4NVn4wDLG3tzjgShTjtnyx/QBZcoWhZ6hlKbjeaLIG7NtxBQYqS+rlNl9E8j36gCplxDPcOd5GiM5wpDXb3CHOOQedqaoXg3ZbJqQfn8NEc228Zm0eH4OsGAc7LKnPSAM/XXDJY+MknQa4/+2/7wpah+KCswf10wJUFAoZImyKFGWJUopfZHRHh5E2h+uF/h2IFLwgyaD9UwbEBF/DerS8tzo+cyTpRc0cKSIHuIKoY8smnMcB/rJV4oXUkIUElIIKOpQ1x0OlNL7hFh+A0aVzMp1KSSEECiKwrgJVdJQXwbsLuMZHOvwDG/Gcsg54ix7kzIkuZ5LWWSwAyDrxr6zxRyNH4/O2ut7WpZfwQ1+k5Hu/IsIDnrc9d+tTzr4yzm0K4X9EDlThO0ShPQWOE8mX3GInw8RQUKHrJZFgaLSODWbzTCd1qjrhk0CCVjviJBAWRYYDAYYDwcoigEAAaU6qI5ASqO1jGJwfLmsprhHLNjPOzZE2TV90hd4nxGK2tcKoZcUW8WSf4TxUf9EMO2MQyEN0gqzqqaBUp0OZy0kTm5uYDgcYGBmOYkEOqXQtDM0swaztkVd1wAaFEXpdoESUoJesliSMukzHMQc+ongVLbLOAvcYIqJ3XUxEdGluTbggTJE0riXB78WROEFdGtJWyAImmPRZzJCYuvlkObjPRxRXVohxqjJ0WezLRjj484bIiDIuNaiaEV7zwSzR0hRAAKY1noJmIDA1uYmLl48h0uvX8C5M1tYX19DVVY6qKppsLOzi4ePnuC7ew9x/95D7O7to2tbDIZDVFUFkF5a0HVdMiIEarj/cpQ5xuSUd/t6XxIZMoaQPbRC6D7hzGNZAvljITXnwWYyZtY2aNsWTddhMh7h/JkzePetK3j3nau4duUSzp3ZwmQyRlVVUKTQNA12d/fx4OET3Pr2Hr7+5hZufXsX9x8+xnQ6w6wjyEIaQ/jlQeqkQVteGngREqRZJmvO+Xj/DHtowJ6THtrDpbLw3qMkhWVz1d2UNgkPy64hO4g28RXMyyG9MeWNK5GokFPXutTskiw7FMZ7sEqXzs8GCgHn/QDpvfKECXGdTqfoVIfNExv44J238LuPfoHf/Oo9XLt80VEOS0uE0IsWlOpQzy5je3cft759gE8/+xp//uun+OrrG3j2bBttJ1ENKhi/H2BWzcx/HtGznNNW5q9XWU5EVM4KoZcQb5TNh+AfyxMgbaCUFGjaTi8Ba1tsnljDB+9cxf/4t/+CP/zXX+Gdty5jMqrcdbb/CAGgKgBUWJuMsHVyAxcunMWZ06cwmYxQlQL//OwrPH62A9Vow7GQAiQFqDvevg4fy8EicBK/Ygyg1qKNuRQjU718iF2SxObGSeLt90WaZu7ewQQG1OxHXKDz7Vojy1vu3NdsubIUwhmGQpi1AFw3EZXkSTyslyaYECQ/EFowtBUvhHmHCgGkdLcqSwkIiU4RpvUMs6bB5ok1/PKDd/A//u2/4N//+DtceeMiRkPdmKlTaLvO1I3xlUs4D42UEqNS4u2rFzEZVxiUEq3q8MlnX+HZ9h6U6jAaDU1a/dx1WGu4Uyp/FLZzUxRWGc8TxF6l4OsyNk+UZIXQL5sIobciA1DXeiuy4bDC5UsX8fvffoj/9l9/jbeuXUJZSDRNi+nBFJ3SFEVI5rITvmEWUmAwqDAaD3H10nk0s1/g6fYOnm3vYHf/BqYHM1SlXRMp0XXHdxV6mToJNDyEM4gUpOlF32W41Fz3RvjTvUkg4zRIpzRsIgLgYzDTu/Dipogzyrld+E1UnHM8OL+04dWOY+dy8Vvqci2EO6d3R/LrOS1km7KkX+EC8jHZRAKztsH+tIaUhNfOn8FHv3wXv/voF3jrim7Mqu0wndaYta1ZsGtnP03NCb9GsekUVF2jqgoUZYlLr5/Hbz98H/fvP8TDh0/w3fQhZvUMg0EFWVX8CSXPIH73dl9EY/BUYkdbtCp/KX5t2tnPJB76x+d9L8LhYVeQt12H6XSGpm2xNhnh2pXX8eH7b+PNy69hMhmibVvs7u6hrvXWC9pPnQZPQWgerkihrhvs7h2gaRqMhxWuXX4N7711FZdeO4fJaIi20+sfldkNalkP248tR2vQOZ+ok9B4cu8VWS5jpJiqy+LoaH21lus63mt5LHEVbZ4Kfi26TedXg1BUvndAuBICTh3cbl/92DxEdNiUq8itkc7cBBx42VXsRWENwQbTWY1CSpw5s4W333wDb129hK3NEwABzaxB03V6QW5RanR2vhWvlOXPhTEAmq5D22o6cerUBq5efg3XrlzCyZMnQATM2lbTF9iRyT5b5l+PbOfQf5N/2hQfWEqshUtBeT8ThD5+khKiBWLdhgDatkXbtBgOBjh7ZguXXruAM2dOoigkZvUMs1ljFt9q3ttHEW0fkoWALLT7T6OwQlkInN7axGsXzmFz84QeGVoF1eoGLeXxbDpu1Xd6y/1OKE+3OT+2nNlCUsSz5gF6X/4uCY9ii/WN+Rxbf9cbDpkxy4NkpkTrfxbQM3aAH7bNRUIYj4HwupAAwnWA5DR11r/5n48WwdpJ6zoBHPfVHJXQtfotAuPREFsnN3F66xTW19cgCol21qKzVh9ST5TXnLwuBE09OkKnOtOgC6yvj3Hy5Amsr00gZQGlZuhUh4IEAAkF6fLhdcfLjTl0EttxiEjOUP8gW3fg5fByzONr1H++d/vXl1iU0qvBpQCGgwHWxmOzhW8BRWQogW5w88QRARU2PL3SXEGZyLvhcIDhYIDCILJSqhebjoO4WI5grZ+IGsGiO7DolBAiMBQ0FZcb/iK/Y+AvsO6FIKlBK75qOkjBVkpbfpopkLFj98WBmwNo9iOZDbQ/JIJCghHC163dm05AmAXjIvRHI65qztmlgX6NzkIIlGWJQVXprRWkDhnVt0vRHYZ2CYEhIxtJwkB/ASkKVLJAWRR6pbu7LbM7lesWIe/nz8Ev748SzLEq01iRqAFGo6n+ow++HAidEWvQCEME9bPUD0MqAaV0/IE+ptxyJGAJxBbLJPqeYhsRjuCDEXARdu41cEaOymztEoKCqce1e1lGuUyD5mO4CLkdi29YLCHXjd/fna+iHKH23BGGmxZmxqooC+Ps98ihlH43INmg9q5F2wEdOjfTZhHFPi6Lr54jCw/T/FxOx0V0iNeB9Vc774qpW0EsXsKiLP94Lu9Ju6EWQgQxJfGIaDt50m2cycH0UQQloF8Yyq/hwwgUHJznemJUH/HT5gO4yB3PyZxEzmJ7qTg0ADv82gkCAswWtwCRWaTkXkEM2IkIG/dQiAKi8DsVzSvn2IptAVkYPqTe2ToIDRKN2mYp2HEmzkyyDTp4kxGz3r1F2ceD+rtsvNNNdDovQpdlkVNKgbIsICD1i3uaBrNZg7Zl8bpm9TQRoSwKVINKGzVFiQKEDh06xfZaFhI29thsh+Q/gn2sQhn1+25hXhuw7m3Np4U7ECAtI/OuDmwcibRJzDETSZcqk6KzjcH2vzXiur0KyabRT01jst20XcSUPKyMpYWCUTA/r9GL7+5YfOb4I7T0kyhECnXdmtBHvcnh2toYg8EAVVmaXfP1K4frmd44vGlbTKcHen/mUu/PLKU3xmzA0I8jS8DcIfi7sBT6BbqEKfocdyljizKMUV0kvgdxP4Rg52L/RPKL4HYasj5Nzrvtq9QAmPhd/QaqyXiM82dP47WLF3Du7BbWJmOURQGlCHU9w/PdHTx8+AT37j/A40ePcDCdolUFRsMRirICFOndP4n8ahFhFIpnArmjIKaiFAMWm/1LatDXl31nNwEgMzB4d7PwyCt0uKj2vnDUtgjN47Jjvo+M8WmMPHaLRDo+RJGABGlPCij0rStN17x/gz3z4KHlt7ZJduMHzLS8QVphvVZprQWjO9nHERkoRo4vQgsBKSQIOhjdvui9qiqcP3saV994DW+/dQXXrryBc2dPYW08Mu9DAepZg+c7u3jw8DFu3bqDb67fxO073+HRk+c4qGuUXYeqrPSOovjh0OeHRbCkacJNMAu8eGgG8HJgcih+99HeWbM5wkzWrAdgbmYMx9mSInfQoE5H+j3YbaewNhnh8usX8ZsP38dvf/Uu3rx2CWdPn8SgKlCYd5gQ9KvQ6lmLaV3j8aOn+ObGHfztky/w17//Ezdvf4d6NgOEwKAaoCgKdMr6rLn+1sJXBrHMseQWBVxMiL0XSn06+odvoHZPOzMOOT7sUNbyahYhJyAhhPJvCnARgQwJhQnEN1t8+cGFAoWI/fQc2t6P4cmKeTf4SJXhIP1NJqqJiBZnZwqdjWYvCSud+Mno6LFDaAFoiwe6YTZNAwJhfTLGtSuv4/e//RB//P1v8It3r2Lr5ERfRGZjcrZUf2NNG5EXzp7GhQvncWrrJKqqhBACN27fwazRL+YZyZHh1D8Wjz6seIphjUjd2fWL7u0igxcH1vOMteMnh2rQsc0ZSgbdsufzPMmes5Z61ym0Su/ms7E+xtvXLuGPv/8I//aHj/D+O1exNhnqhtx2+rUQYH5dg2w66KbA+XMnMRq+i+GgwHBYAhK4fvMO6tkMUhYYVBVKt8EKmYbirXkFmP2cYdDX3wP3J+s9QoltSWfz8Jjidj4luPhmwbwbAR+2XhD3QwJSG7FuBY3d4d9EzEmYyETSPJ2sXRBVOHdXW2asoMy+eP6ZeeJjkZp/2PMOPF9pWzgMXHgrLDZc0jM+WF7/PXYIrYXMCuYGVVXiwrkt/OaX7+CPv/8VfvHuVYzHOub3YG8fs8ZMpJjOQKQcQ1BQqKoS6+tr2Npcx4cfvI2u7bC9s4udnT3cufsQU/Py+UElk+X6ParN+3kkyXrbggRmIiWa7DGb+SbXHsJR8spJmcRWOB5LvcfySO0tVt2fmWXKs/fJTdaeL2mjToGUQNvqN0Rtba7j/beu4LcfvYf337miG/Nshv3pFG3bQdkAdr7KQWjk7BSBZi329/YhJmOc3FjDe29dxaNHT/Do8RPs7Ozh2fY+2qYFDQeB6e+iyJzT1nglXIyIScX5M0L/rjCc2/FVCyaWHxOL7ZbCbVyTeyuV3lM0Omad0dw3bI/Z+idEkyL+ePJMwqcJ213S85bsmLhuwKV29CgeFaIH76yujGfDlhi3FXJ16FdUUVS5xy6oVSkd79upDqNBidfOncZ771zB29fewPraBF3X4dn2Dvb3p+iIdDwDM/i9F0D/7roOu3v72NnZRdd0OLm5gXeuXcF7b1/DuTNbOoa4bdA0Gp3743y5cZjK9/GUCJlvVG4GJdqeKdfEflz5qcvvF2kfROIkYjwujNXtl4zx6yQZBhnoO5ZFAqoDZk0HQOLE2jreeO0C3rp6CefOnAIANI2dGRQoyhJFWfgZMucp0B+7qBPQy/1nbYOqLHD+/BbeuvIGLr12AeuTsZ58qWcg0hFm1sInY2wSKfObXIyIv2nry2bT6lF92UN8aAv284B1WIjwOOfVmZ1PLZclwTml4cP2OOe6BuIoiPKLVpSEDhQzkLDRxIwU/Jk6dHZGgh913S8zIrk1Q0aBoL0I1wyy20r77NkqI9ewdE7HEKG1i05KiY2NdVw4dxrnz2xhOBygbTvUUx2/odfXsdUYrAJsdfu3t0p0SqGua7Rtg8l4iAvntnDxwlmcOLGuX0w/a6AU0P/qxoyfqseFtZTMJbqWIX+/x/N9+L0b6dKjx1rKWMWlnk1CoufdaJyb793xzpGQ2tYm6lCUJSZrY2xunsDmiXWURYm6nqFrO0ihGzIplW1n9pjlwXZ3eqU6gBSGgxInN9dx9vRJbG6sQ4pHaNpO8zFhUYNc1B6URxIdrKM/Ioma66mOpAo0/IX/MtzZcma7Q6zzNzgfCmO6vjA7WpB95wpDTPeT68RO+9HCjxqws7VSxCeZ3cEbBadH0a0ntlXeIgv1nde+QkA7dghth2opJaqqQjWoUBR6PxzVdRpFpR727OoK09J6RZjV0jCrPQSAYVVhfW2M8Xis81cEO+UL+/88muU6zQ8srkW5Py8BLh4fKR2XzfSqaMImsDb5Gctl3C+a2+9SsesQlQBIQigBSRodZFG4PdmslUvM66DpmI0E84VaQ9/xN6snaUTTqz2GGAwGkEUBoA3ilEmZMYT0qCFIaKS2XDr+Z/zfPP7B1xJfDGa9GoCw7wcPEqceDiEivuj8fB6j7a1bbmknJRP+Hj46U0f2h/QnA38y057FmdhRCjbWxI4VwWX5lpDfxaRP+IO111idQsQ/fggdiAIpHot7SKyam9waW/7zY8pctsatrV6RixIcUpFM+S+h+L3t5vaP8Fxmvsajoa2MnuyCtyvZY9bNIqH9LlJzCAEKaFrOJ+odCjEnM9fw+AjnJZAIljBZ9HcGnmPRBq31LxVgsgKR9N6CQAU7tAn3N8eRAfM+FdaAEqdEriq9+8F8IiNCATa+RBiY7mNPfn8NrUPgSbF737lnwEcEO8yEYB6MlKxOkqWF7C7jLQxzOgKsnlkB8aXHEKGP4jJYTuxofRT5YTX6ESDw+1SjiLWTyHp/jiGSz536zmPe8ufnC6tx27uJ4GwzGEQWujqjK2D57Xy2Ltz/GuntC3J4VBvgCuUcmqO0sMSU3Men84c9ffblcrX0TqJs/R+jDY73coSEj6WgpLr0iKE/vhb4gJvYFlHtw+br6sfUOTGPs9WXf7fgrJYHiHltpNeJsfjRhjeMnxqh47tMvBX2oX8/SerD7YX7PTJ9cQPJ0ZR4Qbro2jfdKvxzLKWkqIX7HidS3hXdRRDLKkTQW/v8jA4x4gYh/JUOUl1sZMgq7dyWCB4mRfl4xCHHz4VDQOnQhlyEWnR3RldiwRCeVzsLn8ipG3Mat8JC8A9BCMXoNbcAHREFrF3hWpGN4vMzk/kRw7N8AUDPznlrh2unf3sjJZyFjH6bZ8FHj2Akih7nYTqYNz0i2yPJbHE3OoYc+gVITz2w3bYOJT85MCfCLNPvq9xxhd4lxb1J1q/r89LbUex5xv8s8MZ+iPQ9iO5i/zdAVel6v408zj0jXkoW6GE8AHySIv7AoJDLhaNeqIPl7PZ13IkSfWJGB1eWQ8CQQ4fDlh95/BHNxwQbGYJZSvhjdl8NMsQ+XBXi0dhVk7k3js42pfMKWUZPfv9WP5NolUz5erAKqUcygyNXNfSI6UwzeRwHDv2So8GxkDmo/EO+t+qnj/BbTpYK8O+LaZ5PsWMYW4Sz0aVzHBhhBASQc2RaOstcwQE6amS2Mcaey7pRwUaCOX+u4csuTxHdEtOII4gApJupFMyLEVUJwQWq6RgSAtnYFvtGAiXMFH2OP3tPCdmycvWbqUvL0SFUeJWpF8lHFau7YFydxZrEcxZ2OPOrTsO6cX/Is4SFkJ0Vfe6Yrlh50dLzsBPhL40/Qilziug91Tc0v0DiLnq+v4xSprXOLVfKnDmahAZsjgFzy9nrsKjpWermdMxxc0IIO46jW5DzaCssTBoE9THDYKsl8vEWDuyE9Ril2rsFOozb+/uwXhPyauo9zgK+TCz6j4RJovz7WsI7zAsfuZwC7L7snXJ09t4NuPP8iPWb8HaT7JTF0ZY/F3aZSJIubnk2xc/Dy8HlZYegFywve/WUFt5scM5SvkQRffFuWp9ERGmz00HemrfeABvLof21hgk6jnaICue0Kx5T3TFDXAVA7EWD1poPb8AiM7s2EmGvTRRJh4rYluNRY0qxFSXOi+w5s2CfxAfNPorMSnQTqBGs+eQjBaDrwfrqg1Eu5M/eXsmNn3y3pUUcKe+bAljV27YZXRlFfwfnfn4I/VLKIXxelHaWn5OU2Runnv6TWMgmuQVqyiFoQJ797wg2Q/4cWdT+VX0uHlljmozyTLXjD5cAt72x2xfD+KH56mOy+tp0BEhhdziKPCQBkzQjCTEdIqO+f5Rh9ePW5XFPhjI+cBPrF8Rus8hA+1shRFteUsbOcHcgOJL7GvG6LxszED/v6CdvPCJ/hVejb7hN56NfOoT+uSIPv3G3b3PqJFte0nH85SfQyHo5jFCmj0U9qeeyKE2up8ZQb839EJ0hYiuawvDf7NP0yKzvwaCcFMbXaYsJCb+NJOOReC47yyVZJJxDLkFcXVN2eH8cNQKHS04ceVYGoG1En+fFztuR+ziktvHa88cD5wkRwjo6QmVzF1qQjrjNYZmzKy65KJtqjlJeXjqEfmGyqCZ+TPTqfWamBSkkjemoxPkVAWYnbNW34ZDsHR99kmPBfeKRziCnC+zNkTuE/BEU7DnhgMvAL1mrus8QEC4Xh3Y27sGhUeDxgEPjXASa3a957goLDjksPiblz95/YevFvnkgj74KRMLYEIpNFKax2YvEpuHvHNLrgwWCXZhEdJGn9Cbchdy+H/atXv55e5sk/BL9Ft5rQdZ/H43qCZXmErGGFUIvKf2xDD8svjmgdf/Fs5U/WytiKUmmvuexlfjRJSaJEAl6uTTB8TQnAP7Z9QwBOVvXH8v4V4j/ZbNtSsDvK2c4cfBb+tkyF20mwWcFeWxIzKGdXs7Z67FGmAhAt+00B3MHkD6yL+QS/q79+kY4Z4oQ+fg9PujEejrPjGHAoY/XfJjt4e0L7x8XNjJxqSHblreM5FPlUN8+rxVCJ9JTJbwX/QCgPA9no91BjpDDYlliNvmllAVrCn1fBBg/66mMZerIeQBCmgl/MI479untimgKk88pPHaHUPSPKy9gV4DH8QwehaXbI8T5rxOfhleHc397UAn7jm0bScdGMIJb30hQ+i1UZi8QXwHmE5BZW5F8twurXxhnErpvkHhBco5AEiGfd7gfvGWgp+qTesk8sHS47RHbFvo78/GOtvshA3oPnbHeLta96i3jDkjrfRnHVSxHR9pFHoof4y0sx0163iQLhFUVWZ1REo6DIupE7sq4F84VD73Wktd5kF+BvWA8sKs1dG6xl8Miq5n94/9IOL4My5OlP89nML37XCBmr7nb1LHDSqd1fN7o5HYXNShGBBebLeB80MpcEntf/Chivktyx6zw2VgiH7oBaLMCQNRL+Fhm6ssFXruHY9LHSG+yi9qIoLBdccYuMt+Ci/1lSUHHY8XKcRb3gO0T/oGralGo9fcZnTJ9/RWlzIl4hOa9QOgDMWcWubTxZdGP1CKlOCUT1/V1jxP2rbAwCOspI7PfgwIjimiQEA5ALdY4k91ydgBuNlAyDh0gYPixjV3/8zt9uhEhUz/kdNL+ZLtNn1kw4letODT0JmJMgyn5eGokGWJblPeIrQvlJohHY3bM7MDkHoAn+l4TN1RFSZylYO89bkRWD35n5lcM7/MkSnK8OfSxk0WBOYfkw0enz8sJ791Hhejvt2jnR5f+Bp0ngXMkQ2xypxc6Kz3H9ZFm5EEizjMxlqNEQpjY4bxaoVeA/9PvAA920Q8QGg4BA/Qnj0r9xngUGWevcfHIwkfKCR/N4iPi9N4ePnRQuNHFpWf8HwAPamN1xTQKhz+rZTgTqfSI6VA4fuQMcN1edn1VENVHj1bmcDzc98vPm0NnW5z3DQQNwFlQAsFQeETkC4Bv4YNavpC+MeSoD9p1TvXiB5QfQhKEjllNcBOxp8LtuWH5F0cSCpLGkuuLnpEytKOQ18VODosEfsOYjDslIp18531utDsNmB9aIuLQZgchMj5rb+FrrW1sSdhXTF0Y6kmAQWaEcc18z4uAMYd8lcevcLDkb9ByNy44v5/zBPTG265+ADtA8thr79ywOTg3eJqjsRfmF5vW0vykMZbH1xxrhA5sjJ9MdFMxJGROmqMKs3iXzs2MIpn3fX8vb0amsgmI3wt3rKWM2zoHuvQ9zGF1EfvCgYoy17heH2wUHHoo7LV+64nojU32MhdcwEb/yCIO6F3vK5XArHT/IQi/R0Tk2ZAwnBwWR/1OT2HNMC+RRWhiSGZ3O1V+pyMQuZdp2h2KFJnd8RmX13zZ76RqP8HqbBanbf3ZORS1esHUux297HFiuvXZIaHjIhyZRfxcIoilmItDj/g8j3yLysuxRugXL0u6hVxv/aGqi9jfo6Cf6VxS6LeBecIRJ/vZSXm4Cl3EYLgI9n96zr6DWvBjZDyXPFbB4Iujq5azWQ8DL0eEZWgVyaAUXKivCtLYGULA+XwFecQ3KB7uuCkYceTp/T1YG4DXEx/wkjhmw3Qdr4Yy6G9jP+yu+eFooTdUZX5xAT1LSH7QsTfCETrcOdYZF9ETDeYI7bjjYzpiNOb1vmhbfs7Dg+v5t1wefLeR9PxLi9BHxksHin0V/hOy9oQW9+uhXzJrEFpK/0bk7yU95WW4+nGV5SZWOO0FA6/I0p4rQZBHzOh83+YzZT4eLWP7e0ByXo980JfmozoOAbCByNan6l2vFnnt6GBdEpzHE9Pfau5jEl1tOMALPTQeFYXPS4VoZ/3JbjdYe8oMQX6WkwVNSV8fFq21G9trl7IRr3WwFhF6hNA7MRl7MHi4dkSiEF6XlMOM8fNzyMvx7HamEhV7zgtlSTqsn5h+v2HXmY+idDIsU+4PjdtuakSxLsWfdHaGTqOlboieurgGLQFp9+89qti+Bhi3HQtBOObivBwe3by/MZmhIQRfKIJEwdKkq1nin3HtcLQW7iX2TdOgaVooRXrWSwr3Hm7iHLrPy8GpovHhKqUwmzU4OKgxrWdoW8XifPXTJF8JEAZR267DrGtdeiJeUg6u9DHvNQjZH0fEriO0TYdm1qFrlQmXEO46DdBCN9hCousE2q5DXTeoZw3atgVQobCxKGRnDuHuI9LK1Ik3WdzAaXRqmhb1bIbZrEbX6fc42vev+DHU8HU7WmRsIy7LrGqJY4j6E7LvJu3xRGjoRlebRlfXLRTpBymFNG+QBdwKTy6cyTjDUFeSRjAJRUA9a7Gzd4C9/QPTGOwT1QFDymzeIg3qKaVQ1zPsH9Som1bnHvV3V6YQkR6h6EFCdxjLgZV5F/n+/gHqaQ2llDH4pKkPfa1LD2A6m2Fv/wAH0ynatgOgOXXQt62xkWceQX3r9mzeugugrmfY2dvD3oGtI/zo73M8rMiYAQc+WCvRw3EWd/50cCywwQjOQk+4pUFEKfRD6TqF/f0pnj7fwbPtHdSzBkVRoJCS7Z4UcunkHSGAQVcARA6x6qbFs+09PH7yDNvbu+hUh0ICEMTe5a1AilBIgUJKdKrD7v4+Hj/ZxtPnO6gbg1g2VoJg/N1hvEfI/PU+Gcp6bwRQmgayf3CAJ0+f4+mz59jb30enOshSNy7P33X9VGUJAYGD6QxPn+/g6bPn2N070K99FtLp5GcWpV+xbm0N1sD1rv+6xxSFhCwkmrbF02fPcf/hEzzf2UOrOsgCkIXOQEVrItP2MZ+ixZZU2Af9exOWF53LsetuUgqUhUas3d193H/4GPcePMFBXWM4LDEeDwEAXdeh67rM5I8X2zC7rgMADKoKVVVh1rR4/PQ57t5/hGfPtwEiDCptH+sHqxxvlFI/YCLC7u4+7t5/iHv3HmFv7wBCCAwGFcqyAJHm4/P00XorNE0DABgPBxiPhiAiPHn2HHe+e4AHj57g4GAKgFCW2nthCYJ9r3lVlqjKEnU9w8PHz/DdvUd48mwbShGKskRZ6jdeK6Wguvn6KEXo2g5t10FKieFwACkl6rrGvQePcPvOPTx7tg0iQlkWkIV01x1Hkb1D4yGMCr5b/LI9k/sH9HEzxEuPQLu7+/j2u/v45uYtPHz8BAAwHFaQUugG1LauYgkhbydoS71TnWmYAlVZoCOFx0+3cfPbu/j2u/vY3tmDlALDwUD7q5V+g63l0UIIFOZ94/vTA9y5ex/Xr9/GnTsPUE9bFIVAVRUACMqURYZOWJ24v7nrtF1QSoHxeARZSGzv7OD6zTv48votPHj4BE3ToSwkCqkj/uwIpjqCUkBZVhgOh+g6wqPHz/DNje9w4/ZdPN/ZAwCURQkphTF8O6YPi+yDRuauU2jbDqpTKAuJQVWiaxXuP3iCr6/fxs1bd7C9vQMhJKpBhUIWrm4IzHbhtsqS6MpbTBKLvXwG7qtlV8dICBASZVmiKArMZg3uP3iEL768jq+u38bTnX0UZYFTpzawsTZGIQTs5iwuFLNT+mMWmxZSYG0ywomNNZSDCts7e/jy+i189q8buHf/Mdq2w6AqI4T2ogytGAwqAMCTJ8/wr69u4NPPv8bd+48AElibjDGZjDBgDbtTdgRRLLhHv85tOCixeWId6xsTTGcz3Lj1Hf752Vf4+vptbO/soSgKVFUFIaQ1vz3iKoWiKDAaDlCWJXb39vHNjW/x6Rdf49a3dzFrWpRlgbXJGMNBpXdAUwRl6kQZekGK9CinFIpCYm0yxomNdciyxKMnz/H5v27gsy+u4969R5jNWgyqCoNS1wGZ0es4SulQknkwLPdzcRNOBPtfpyX3N8Rbm5+fl095OTOqAdhhTEAUEmVVQs0Unj3bxr++uonzZ0/jzOlT+PUv38b6ZIKqLLC9vYfOPGRnZVv8N8S9KEpMJiOUgwH29vbxr69v4j//+k988ulXePpsB1VRYlhp1HeUQXg7XtMVgdFoAKW0kfrV9dvY/Msn2NhYw9raCGfPnNTUQSkcTGu0xset7EMn4fbYKAuJ0aDEZG2EVinc/PYu/vzxp/j475/jzncP0TQdJpM1lJV2QOmOqae5Le0oRImyqjAaj3Cwv4c7d+/hb//4HOfPnMTG+gRvXbuEsqowhIAyrkkF69oTrvPb+x0NKzNaFHi+s4dP/vUN/vSXT/D5F9exvb2LQkoMhxWKQoJU5/h8aGrxp9nvoE7mCiiTMjFgg5bln3F0DjjGK1bKsgBQYTqr8eDhY3z8jy+wNplAEOGDd65gY32MtbWJG6oE65AAWKxDgbIssb2zj8+/uoH//R//wJ8//hR37j4EEbA2HqEqC5AywUKIO5mCkAJlUZphvsPT7V18+sXXWJuMMB4P8etfvoPTW5u645QFmrZD17UaFWFcWmZyp6o0HTioG9z+7gH+9OdP8Kc//xPfXL+D6UGNqqowHA5QSOGCliSz4jSV0tx+PBxCdS0Opgf45sa3+NP//QSj4QiFlHjt4jkMBxUKOUHbddrtKTQdIDNxYg3Y4XAAQODZ9h4++fwb/J///Dv++o8vcP/BEwhIjEYDVGWh68Pd0/GUMrVhIuh0gRCpNyz8SqzfsFiNyApOKyLOQXfZopAQskKnFA7qGb6+fhuq7XCwd4CdZ7t4790rOL21aYxECkHBeheEwGzW4tHTZ/ji61v4X3/6K/7Pf3yML7++jbpuMBqOMRwOIKCNTO6u5TuMEkk31A+HQ+wfKNy7/wT/+Zd/ous6bG/v4tcfvoPXbSMaFmhb7amxI5yfsRPY3tvDjW/v488ff47//ae/4dPPvsLTZ7soS91pysK8/dXQH9tpLbx1bQcqgLIoMB6N0KkOT57t4uN/fImuJTRth9/++n1cvnQB65MxirJAAd8lQIAihUJq26DtCA8ePsGnX1zH//sfH+M//vwP3Lx5F7NZg/F4hMFgAAGBjpRfTRgtcnBNxh7uIcPuEWXOx3RcZFtLxvkM3/qOJUJrrilcAxJNg729A3z9zS3U0xl2tvfw4NETvHntEs6d28JkPNRDonFXKSI0rcK0bvDoyXNcv3UXf/vkX/jPv3yCb27cxsFBjfFojPF4aIynDsoYjnmzgtApBSm08UhEmB4c4M79R2j/8k/s7u7j6bNtvPfOVZw/u4W19QlkoYOHVKcMp9b67O1Pcef+Q3zy2Tf4y8ef419f3sSzZzsaccdDVFUFwC53ItdwFNOMlEIHoJACVVVhbbyGnY7w+Ok2/vHZV1AC2N7Zx/vvXsPrF89iY2OC4ahCVZQG7WGMZWBaz/DwyTa++PIm/vK3z/HXv3+O27e/Q13PMBwOMBwOjRu1M+7G44vOACB+8+//0zR5bqZ6+5MFOzCUsQnDbpbeLnkObvJMZ/RYLyNv8QoB408VaFuF6XSKdjZDVRTYOnUSly9dxNWrr+PyGxdx/uwWNk+uYVhVAAFN12HvoMbjJzu4/e09fPnNbXxz81vcv/8Qs6bBYFBhMh6jLArnh9WNR5r3CIZ72+k70f5oKXQHmDU19vYPACJsrE1w6fULePPy67jyxgWcP38a6+sTDKoSShFmsxkOplM8eb6LB4+e4ta393Hj5nf47rsH2Ns/QCH1sD4eVZCQbA9oPZnk/cnCTLRoe6GQxo1GwLSucTCdoutabGys4bXz5/DmtUu4evk1XLhwGlsnT2AyGqEsS0AItG2D/ekUDx89xY3b9/D5lzfwzfVv8fDhE3RNg+FggNFgAFmUzk+tRwlynSJsDiJoF9TTZvzxtA3F+3Ekq7+Np0YXZf3/YYbHtkGDAEiCFIUe7pTCbFZjOq3RdQqj4RBbWydx8fwZnDt3GidPrmM4GABEmLUd9vYP8OjxNu7ee4h79x9hZ2cPUhDW1kYYjUYoykKjZ6ecXi543v3lDVrrKoXQxhEUpnWNvb0p6rpGWZbYOrGBCxdO4+zZLZw4sYbhoAIpQj2bYW9/iqfbO3j46CkePXqGnZ09qE5hOBhoZB4U2iPRaU+ENXKl6G/QAMxkk+a3Tddgb/8AdT1DIQucOrmJ8+e3cP6cadCTsR4BhEDTNNje3cWDh49x5+4D3L33EDs7+ygATEZDjEcGmd0CBEs12CM+jg36I9OgY6PK8qK+xpcqk5RtKOghGzQ5xgjARo9p5Gy7DrOmQT2doW1aiKLAeDTEeDLGaFShkJpBtV1nYjWm2N+fom0aFFJgMtaNpyhK48HQQ7tWSbKGbBsQ19frX5iIOEWaRuzv60YtiDAYVRiNhppLFxKkgLZrTVxEjYO6RjtrIYXEaDDAaDRENSghJNg+draDQesEu5LbN2w/G6oN30JqF1/d6Puu6wYQ2kU4mYwxGg4xGFQoyhIKQNu0mE4PsLu/h4O9AzRNo0eKwUC7BAtpvCo2tltTqMCTJMIGCHY+euzMiRb7JvjTtueML4Pi48FP32bYsWPJoblotFKQ0L7ZsqowHAxR1zqm4mA6w95BHVSKD8dUKKTEZDzEaFRhOKh0Q+w0J1aUOBOZ5G15IoWOBCRpjj8ZFajKEtO6wnRaYzZrsH9Qw29eDleOkJr32kajh3S9h572MTufiL2VhUIAOjdtXWA0GGmPTDXDdFajaVo8fbqt78bAqwJBtcrYDi1KKTAx+pSV5tkdmw7XBvZiXY6DlPwdG4CHfeOrMMcWix9tol4W1wTFP5lD06K4JUGsdyszgyeF1FOwcoRyoNA0LdqmQ9u1JoRZmCAkgaIQKIsCg7JAaaZs2075Yd0NnwxpyNaCMNrpRA6njXJu6ldIlIXEeDREWUjUMz0l3bat9kMrQgEdVFRWElVZoCoKzd8FQKqDMt6UcP8NPUTq/TQyxhgBwgRC67WHelJJCj39OxxWkIXUEYttq113nTLT59r7pGcjBxhUBQaV1sl2kBA3Y6oZPsxAu/j5Jo2nv03FeB9T2ySvTCbHHqGtKKX0Rn9SI9GgKjEYSHRDM3GgzBSv45oCstCPQkJ7Btqu1Q9LpdTHi0Vm7ldI0xC0q08IHXMxKAv9t6owGg7QtZ1rPACZmBBtyOlRmdykkEZPnfNRgZAUoKBAQgdUlabTqGEFZWYErc1gp+GlhKsnKWzci3EXWnA5bpPJC2RBg+6p3h4qnfcQLsgLiLoeIQYEP1zCxB90JhxUpy3MxIc1XOB8yLojtGaqVymz27ywIxAvKIrgdkaA0yC9H+H1UXYjFiKUUqCoCiiSfhW1maa3AUZuyt4N556rh6v/vOeViGuhKZVWwmyMY/Ux7zPk7xMvCwkUAqQKuD31rM2iCC06H9Un7Bhh6nxhL+Mc1yJwhl/z3zzTKP94hE5KyrQ3+/2YIfRicuM2Q1cdhNSzgX4TcpbOxC3o4BzlXvjOm8rSKok5v61xaXT3IZoptmkGYhuy92QgasCLdbI0TZnGHI4mNvTVGZaFMBvx6AUCBAmhdKCTjkg0ngxxyLo5hpK+p9B1KNa4eruo7cGZLpMyIv0rgXHG1fKXROkj9IAeIq394vDBNnwbXWbiM/QAQEF+scYmhyBtsL815e5Oz+4pF9ttIsgU+UQuBoKhseDlhxGIsU7ae2B7FP/rNNbXGGS27k/VETrz3e6PAtuQ4f3+ECJ67D3oym7HHXdJwlFvsWTG9bghUJRaRL+ZHDOEXlICJDaNmuw0sUkS3yl/9i9Q7LDtXsVmlBKRTnwLhiOUkrk2z/n1mkX/ujjeoAmso4q4K72cUvpuFuKTrzLB+mcfWRaM0tmnh/BqSpFOkL80SB3tnCNieAQHAnsN53H8Tkx2gb/SpHWtLfcoeXoknSHXX4TTy14kA17pNBRRBcaUZo4EtMro73y9plNbKpM+WZH7ExbrNg+EszeWkghJzDp7dji6sQT9ka9U+HY3t8uZa19OhM5IcrNsyP1J9GEdzDcW/HT6mL8eke2Bn0CZFyhlvgvme0K2DgJHwLzaia4Wubqknl+mh7JOnWrYVzb1nutniMxG7/WrU3Btml9PuRFvj28mN15mMghSU0wsc8OJDm43fYqtDrFozXtdD2iKRb2ADR8UfaE0Sa+6fTefrZvo2lcGoVPpb8greXUlv7cdR5Fcu0h6EM2DlLmXxllzc8eN0Jx32y/G2vdcOkZ3awSZ5FllOMPt04vPnYJx8fBaYXUgdlXEVZOZruzgyFCXlp1y1jdJzCgMvBWZbx6tI11y10W33s9X+GynGz8Wap94t2IoXoYemTSvMEL/HKWPsPx8RqqSKGz+wq5QYbZlzLNyBqoV18l6elm4E1xk7Vt0SxDZJrHel8TUT8oPuSqxn4shj2eZeHhECFfMoROWj/hee/hjrNJCEm1GpmwbnWdH5A+J6LksyimU2F1CyZxEVF3R1ZxzZyo9k87l3VM/L9dE/UpWskBKj8z2UISa/NgihMn1Qud/zvHV1NU2L/95fsiEJ1run1m1nl4Tn83hU55D96XOZjw3YXSyB86t7znMOL4k3lkwjTlOQC/jGImuSOsrA5zpPUZeInY02f8wLnzeYNpz6QqhV/JKCTMKc4bED2FMLOKsGRdEcsmSLpQ4XwYtDj1YVhHDTq5fptRlwGRRDtx70Btac5Scs0R7wWiblIw5zeAwWoU4TxFyz1XBFcOMufic+b1C6JW8UlLmqVrEoHo6IqfdsSXv4z4MR89xK+vYEJgP1BEPz51LNOfOzcDTIgK9c6IBIMKOmO730b/QLRNemvPfM+9OpF2gYi6ORkRKeHrfw7+5Tu6Bhc5fyt107E+PM469NMH9RM9uTnB1ErNxGA+MSbJC6JW8UlIm3c/+iH3AQNI10p6Swmzk5g49CQTuCM1kmHoU+svuSyCiY/1OzNwlsfSd6l1dkS9B/1rKRDm8HePeGDA3vxgxU7a+jNt8XtZal/iLTZLm0ufFoqzO+btbIfRKXilhXo45XtnYRTonwz6QPZwsa4n7RIkfevlSlnITHw6tjuCw79FpKRf2EUpbHo+zifMJ+oEzU8qchL2DhhldhS8snudYIfRKXinJR9vxKR/XG5CsOsi+Q9tInz819J8I1ql5DLL5y+l9oJOxnXNBF9l7QeCsif2zsU+UeHB+FiXAkCG+m34VQj/DfMXnjJdponh7omR3qnTEc3Vs05BPS+zKnP7urCuWeXPsMcfje7izex5xGTxxqCS3DPoe9wqhV/JKifNDK4a2ArGPM893cu7OIGaWnRcZy9su5Y+8tRmk1i4Xt7Yw647IE71Qxz7eFuvmx4w4xiXxKTOIo+yJVM3M8sYejeZpHntv+KE+Jzl3KkX3HPn4nTuZjYyxqglyZ0Zsvjqf/xXkNRBsRX6Qf/y4WXF8ca8+plOtEHolr5SUrq8yvrrI/5yeWMod0Z9Fz+XzrPQ4zjaOPc4XdAid7JdF3NxrtLCc+Ww5P7LYdSWCbWsczx30lZgtLxndctZNkjir6WE2PvC7MDGkJn28d1V34iPvV0asvBwreRWl5GAUiMj9mM9BAd9T0s7L8uAWriNrKd/KZJ/J2/R4CstdBp3mccKYjvanXQKlMsgaWOwZ74O7goIKAoflNDS7X8s+VfpmCvl4l/L5uP4y6XoHqrAdhGlj2O1TPjUX7G2sEHolr5S4nZMClNBHPFeat4jQXEGIrHeHHvoa/f6koABYAh0DTIzUglvPiWMj7Oa5qL4Yc2LPRToA9KPuwtFjrvh6NMxYH2V2RN5/H+uTH2Hiq7hqgv0N/bn9BVPk+Yrzde9bZ/r0OLmQ3XXLHI93OWX7LSXX9I5m5vsKoVfySkm6jQGlXxftDUHsYyXHQfsdA4fwkizDzXJ6ZIpJ9zDuz3WRHvG7YoL5trmbq4dfI1Mg2Bc7vU5kf7pyGSj2Ojd6PVXMjkje7hB7P/hI25dfjqtzD0vMyMNv7ghPGjQq/WWF0Ct5paRMeUrO5xd3/fx5YbAgtZP170WeYpZhUEzOVveIs4hPekm5eU/+InOL/RAH5rbQpy3K9k11BUZDNKIkwyJlfor8kBddm9vrou9NZpS4TATi1SyJ9yEYfZOo5SXEXqkz67Vd4iqPUZqdWyH0Sl4p+f8BvhI71HNUaB4AAAAASUVORK5CYII="><title>DataLogger</title><style>
:root{--navy:#253044;--orange:#ffb333;--bg:#f2f5fa;--ink:#263348;--muted:#647087;--green:#31a268;--red:#dc393e;--white:#fff}*{box-sizing:border-box}body{margin:0;background:var(--bg);color:var(--ink);font-family:Arial,Helvetica,sans-serif}button,select{font:inherit}button{cursor:pointer;border:0}button:focus-visible,a:focus-visible,select:focus-visible{outline:3px solid #398bdc;outline-offset:2px}.app{max-width:540px;margin:auto;min-height:100dvh;background:var(--bg)}.top{background:var(--navy);color:white;padding:calc(env(safe-area-inset-top) + 18px) 18px 18px;display:flex;justify-content:space-between;align-items:center;min-height:75px}.brand{font-size:23px;font-weight:800}.brand span{color:var(--orange)}.top button{background:transparent;color:white;font-size:27px;padding:3px 9px}.page{display:none;padding-bottom:calc(115px + env(safe-area-inset-bottom))}.page.current{display:block}.hero{height:175px;position:relative;overflow:hidden;background:linear-gradient(130deg,#253044 20%,#657a90 65%,#f3d2b6);color:white;padding:23px 18px}.hero:after{content:' ';position:absolute;right:-10%;bottom:20px;width:80%;height:80px;background:#384a5c;clip-path:polygon(0 100%,25% 40%,39% 70%,55% 10%,72% 60%,85% 30%,100% 100%);opacity:.85}.hero h1{margin:0;font-size:25px;position:relative;z-index:1}.hero p{position:relative;z-index:1}.system{position:absolute;bottom:0;left:14px;right:14px;background:white;color:var(--ink);border-radius:13px 13px 0 0;display:flex;justify-content:space-between;gap:8px;padding:12px;font-size:12px;z-index:2}.dot{display:inline-block;width:9px;height:9px;border-radius:50%;background:var(--green);margin-right:7px}.content{background:white;padding:14px;border-radius:13px 13px 0 0}.homeactions{display:grid;grid-template-columns:1fr 1fr;gap:10px}.action{border-radius:13px;padding:17px 8px;min-height:132px;display:flex;flex-direction:column;align-items:center;justify-content:center;gap:10px;font-size:15px;box-shadow:0 3px 9px #1b2d4120}.action small{font-size:11px}.action.start{background:var(--orange);color:var(--ink)}.action.data{background:var(--navy);color:white}.action .bigicon{width:38px;height:38px;display:flex;align-items:center;justify-content:center}
.action .bigicon svg{width:34px;height:34px;display:block}
.playIconSvg{width:31px;height:31px;display:block}
.nav .playIconSvg{width:30px;height:30px}
.sectiontitle{display:flex;justify-content:space-between;align-items:end;margin:22px 2px 14px}.sectiontitle h2{margin:0;font-size:18px;letter-spacing:-.2px}.live{font-size:13px;color:var(--muted);display:flex;align-items:center;gap:6px}.sensors{display:grid;grid-template-columns:1fr 1fr;gap:14px}.sensor{position:relative;border:1px solid #e4e9f1;border-radius:18px;padding:0;background:white;box-shadow:0 8px 20px #27374b10;display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:146px;overflow:hidden}.sensor.compact{min-height:132px}.sensoricon{display:flex;align-items:center;justify-content:center;padding:18px}.sensoricon .iconwrap{width:64px;height:64px;flex:0 0 64px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}.sensorcontent{display:flex;flex-direction:column;justify-content:center;padding:18px 18px 18px 8px}.symbol{font-size:26px;display:flex;align-items:center;justify-content:center;line-height:1}.symbol svg{width:30px;height:30px;display:block}.measuregrid .tile .symbol svg{width:29px;height:29px}.label{font-size:12px;color:#627188;margin-bottom:6px}.value{font-size:18px;font-weight:800;line-height:1.12;margin:0;color:var(--ink)}.sensor.emphasis .value{font-size:20px}.sensor.compact .value{font-size:16px}.sub{color:var(--muted);font-size:12px;line-height:1.35;margin-top:10px}.sd{width:100%;margin-top:14px;background:white;border:1px solid #e4e9f1;border-radius:18px;text-align:left;padding:0;display:grid;grid-template-columns:22% 1fr auto;align-items:center;box-shadow:0 8px 20px #27374b10;overflow:hidden}.sd .sensoricon{padding:18px 12px}.sd .sensoricon .iconwrap{width:56px;height:56px}.sd .sensorcontent{padding:18px 8px 18px 0}.sd .arrow{margin-right:18px;font-size:30px;color:#738199}.sd .value{font-size:16px;margin-top:2px}.sd .label{margin-bottom:2px}@media (max-width:380px){.sensors{grid-template-columns:1fr}.sensor{min-height:118px}.sd{grid-template-columns:26% 1fr auto}}.nav{position:fixed;bottom:0;left:50%;transform:translateX(-50%);width:min(100%,540px);display:grid;grid-template-columns:repeat(4,1fr);background:var(--navy);border-radius:16px 16px 0 0;padding:10px 0 calc(24px + env(safe-area-inset-bottom));z-index:10}.nav button{color:#bac3d1;background:none;display:flex;align-items:center;justify-content:center;gap:0;flex-direction:column;font-size:0;min-height:56px;padding:6px 0}.nav button span{font-size:31px;line-height:1;display:block}.nav button .homeNavIcon{font-size:36px}.nav button .chartNavIcon{display:flex;align-items:flex-end;justify-content:center;gap:4px;height:30px;width:34px}.nav button .chartNavIcon i{display:block;width:6px;border-radius:6px;background:currentColor;opacity:.98}.nav button .chartNavIcon i:nth-child(1){height:15px}.nav button .chartNavIcon i:nth-child(2){height:25px}.nav button .chartNavIcon i:nth-child(3){height:20px}.nav button.selected{color:var(--orange)}.sheet{background:white;border-radius:17px;padding:18px 14px;margin:0 3px;box-shadow:0 2px 12px #22314a15}.heading{display:flex;justify-content:space-between;align-items:start;gap:9px}.heading h1{font-size:19px;margin:3px 0 5px}.heading p{font-size:13px;color:var(--muted);margin:0}.pill{border-radius:20px;background:#d8f5e3;color:#238651;padding:7px 13px;font-size:13px}.clock{display:flex;flex-direction:column;align-items:center;gap:4px;margin:16px 0 21px;text-align:center}.clock .metric{border:0;background:transparent;box-shadow:none;padding:0;min-width:0;width:100%;text-align:center}.clock .metric:first-child{padding:7px 0 2px}.clock .metric:first-child .metric-label{font-size:13px;margin-bottom:7px}.clock .metric:first-child strong{display:block;font-size:clamp(39px,10vw,52px);line-height:1.05;letter-spacing:-1.5px;font-weight:800;font-variant-numeric:tabular-nums}.clock .metric:last-child{display:flex;justify-content:center;align-items:baseline;gap:6px;padding:2px 0 0}.clock .metric:last-child .metric-label{font-size:13px;margin:0;color:var(--muted)}.clock .metric #count{font-size:16px;font-weight:800;color:var(--ink);font-variant-numeric:tabular-nums}.clock strong{overflow-wrap:anywhere}
.measuregrid{display:grid;grid-template-columns:1fr 1fr;gap:14px;margin-top:14px}.measuregrid .tile{position:relative;border:1px solid #e4e9f1;border-radius:18px;padding:0;background:white;box-shadow:0 8px 20px #27374b10;display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:146px;overflow:hidden}.measuregrid .tileicon{display:flex;align-items:center;justify-content:center;padding:18px}.measuregrid .tileicon .iconwrap{width:64px;height:64px;flex:0 0 64px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}.measuregrid .tilecontent{display:flex;flex-direction:column;justify-content:center;padding:18px 18px 18px 8px}.measuregrid .tile .label{font-size:12px;color:#627188;margin-bottom:6px}.measuregrid .tile .value{font-size:20px;font-weight:800;line-height:1.12;margin:0;color:var(--ink)}.measuregrid .tile .sub{color:var(--muted);font-size:12px;line-height:1.35;margin-top:10px}.measuregrid .tile .symbol{font-size:26px;display:flex;align-items:center;justify-content:center;line-height:1}.measuregrid .tile .symbol svg{width:30px;height:30px;display:block}.settingrow{border-radius:12px;background:#f5f7fa;display:flex;justify-content:space-between;align-items:center;padding:12px;margin-top:10px;gap:8px}.settingrow small{display:block;color:var(--muted);margin-top:4px}.settingrow button{border-radius:9px;background:#e5eaf0;padding:10px;font-size:13px}.measureactions{display:grid;grid-template-columns:1fr 1fr;gap:10px;margin:12px 0 8px}.measureactions button,.stop,.startbtn{border-radius:11px;padding:15px 8px;font-weight:700}.continue{background:var(--navy);color:white}.pause{background:var(--orange);color:var(--ink)}.stop{background:var(--red);color:white;width:100%}.startbtn{background:var(--orange);width:100%}.hidden{display:none!important}.location{display:grid;grid-template-columns:1fr 45%;border-radius:14px;overflow:hidden;border:1px solid #e1e8ef;margin-top:13px;min-height:128px}.map{background:linear-gradient(140deg,#dcf7e8 0%,#edf6eb 45%,#bee4ef 46%,#d7eeff 70%,#e5f5e8 71%);position:relative;overflow:hidden}.map:before{content:'';position:absolute;top:44%;left:46%;width:19px;height:19px;border-radius:50%;background:#267ddb;border:3px solid white;box-shadow:0 2px 6px #173e6b44;z-index:2;transform:translate(-50%,-50%);animation:mapDot 2s ease-in-out infinite}.map:after{content:'';position:absolute;top:44%;left:46%;width:24px;height:24px;border-radius:50%;background:#1e5fa84a;z-index:1;transform:translate(-50%,-50%) scale(.65);animation:mapPulse 2s ease-out infinite}@keyframes mapDot{0%,100%{transform:translate(-50%,-50%) scale(1)}50%{transform:translate(-50%,-50%) scale(1.12)}}@keyframes mapPulse{0%{transform:translate(-50%,-50%) scale(.65);opacity:.78}70%{opacity:.24}100%{transform:translate(-50%,-50%) scale(3.2);opacity:0}}.manualviewer{position:fixed;inset:0;z-index:120;background:var(--surface);display:none;flex-direction:column}.manualviewer.open{display:flex}.manualviewerbar{height:58px;flex:0 0 58px;display:flex;align-items:center;justify-content:space-between;gap:10px;padding:8px 12px;background:var(--navy);color:#fff;padding-top:max(8px,env(safe-area-inset-top))}.manualviewerbar strong{font-size:14px}.manualvieweractions{display:flex;gap:8px}.manualviewerbar button{min-height:38px;border-radius:10px;padding:0 12px;font-weight:800}.manualviewerpdf{background:var(--orange);color:#232323}.manualviewerclose{background:rgba(255,255,255,.12);color:#fff}.manualviewer iframe{width:100%;height:100%;border:0;background:#fff;flex:1 1 auto}
@media (prefers-reduced-motion:reduce){.map:before,.map:after{animation:none}}.locationaside{padding:13px;font-size:12px}.locationaside p{color:#438dde;font-weight:700;line-height:1.6}.locationaside small{color:var(--muted)}.meta{font-size:11px;color:var(--muted);margin-top:15px}.datawrap{padding:17px}.datatop{display:flex;align-items:flex-start;justify-content:space-between;gap:12px;margin-bottom:14px}.datatop h1{font-size:18px;margin:0 0 3px}.periodpill{background:var(--soft);border:1px solid #e4e9f1;border-radius:10px;padding:9px 12px;font-size:12px;color:var(--muted);font-weight:700;white-space:nowrap}.overviewgrid{display:grid;grid-template-columns:repeat(3,1fr);gap:10px;margin-bottom:18px}.overviewcard{background:white;border:1px solid #e4e9f1;border-radius:14px;padding:12px 11px;box-shadow:0 1px 6px #24344a0f}.overviewiconrow{display:flex;align-items:center;gap:8px;color:var(--ink);margin-bottom:7px;min-height:20px}.miniicon{width:18px;height:18px;display:inline-flex;align-items:center;justify-content:center;color:var(--navy)}.miniicon svg{width:18px;height:18px;display:block}.overviewvalue{font-size:28px;font-weight:800;line-height:1;margin-bottom:4px}.overviewlabel{font-size:12px;color:var(--muted)}.sectionhead{font-size:18px;font-weight:800;margin:0 0 12px}.filetoolbar{display:flex;gap:10px;align-items:center;margin-bottom:12px}.searchbox{flex:1;display:flex;align-items:center;gap:8px;background:var(--soft);border:1px solid #e4e9f1;border-radius:12px;padding:0 12px;height:44px;color:var(--muted)}.searchbox input{border:0;background:transparent;outline:none;width:100%;font-size:14px;color:var(--ink)}.filterbtn{height:44px;border-radius:12px;padding:0 14px;background:var(--soft);border:1px solid #e4e9f1;font-weight:700;color:var(--ink);display:flex;align-items:center;gap:8px}.sessionlist{background:white;border:1px solid #e4e9f1;border-radius:16px;overflow:hidden;box-shadow:0 1px 6px #24344a0f}.sessionrow{display:grid;grid-template-columns:40px minmax(0,1fr) auto;gap:12px;align-items:center;padding:14px 16px;border-bottom:1px solid #edf1f6}.sessionrow:last-child{border-bottom:0}.fileicon{width:38px;height:38px;border-radius:11px;background:var(--soft);display:flex;align-items:center;justify-content:center;color:var(--navy)}.fileicon svg{width:20px;height:20px;display:block}.sessiontitle{font-size:14px;font-weight:800;margin:0 0 5px;line-height:1.25}.sessionmeta,.sessionsub{font-size:12px;color:var(--muted);line-height:1.3}.sessionactions{display:flex;align-items:center;gap:6px}.sessionmenubtn{width:40px;height:40px;border-radius:12px;background:var(--surface-alt);border:1px solid var(--border);color:var(--ink);display:inline-flex;align-items:center;justify-content:center;font-size:22px;line-height:1}.sessionmenubtn:active{transform:scale(.98)}.sessionactionsheet{display:grid;gap:8px}.sessionaction{width:100%;min-height:52px;border-radius:12px;background:var(--surface-alt);color:var(--ink);display:grid;grid-template-columns:36px 1fr;align-items:center;gap:10px;padding:0 14px;text-align:left;font-weight:800}.sessionaction .saicon{width:36px;height:36px;border-radius:10px;background:var(--surface);display:flex;align-items:center;justify-content:center;border:1px solid var(--border)}.sessionaction.danger{color:#c83238}.sessionaction.danger .saicon{color:#c83238}.sessionaction small{display:block;font-size:12px;color:var(--muted);font-weight:500;margin-top:2px}.sessionmore{background:none;color:var(--muted);font-size:20px;line-height:1;padding:7px 3px}.filterbtn.active{border-color:var(--orange);background:#fff5de}.filterpanel{background:white;border:1px solid #e4e9f1;border-radius:14px;padding:12px;margin:-2px 0 12px;box-shadow:0 6px 18px #24344a12}.filterpanel[hidden]{display:none}.filterlabel{display:block;font-size:12px;font-weight:700;margin-bottom:7px}.filteroptions{display:grid;grid-template-columns:repeat(3,1fr);gap:8px}.filteroption{border:1px solid #dfe5ed;background:var(--soft);border-radius:10px;padding:10px 7px;font-size:12px;color:var(--ink);font-weight:700}.filteroption.active{border-color:var(--orange);background:#fff5de}.emptyhint{padding:14px;font-size:13px;color:var(--muted)}@media(max-width:380px){.measuregrid{grid-template-columns:1fr}.measuregrid .tile{min-height:122px}.measuregrid .tilecontent{padding-right:16px}}.settingswrap{padding:22px 18px 130px}.settingswrap>h1{font-size:28px;margin:5px 0 22px}.settingssection{margin-bottom:22px}.settingssection h2{font-size:15px;margin:0 0 9px;color:var(--muted);font-weight:800;letter-spacing:.2px}.settingscard{background:var(--surface);border:1px solid var(--border);border-radius:16px;overflow:hidden;box-shadow:0 2px 8px var(--shadow)}.settingitem{width:100%;min-height:64px;padding:12px 14px;display:grid;grid-template-columns:38px minmax(0,1fr) auto;align-items:center;gap:12px;background:transparent;color:var(--ink);text-align:left;border-bottom:1px solid var(--border)}.settingitem:last-child{border-bottom:0}.settingicon{width:38px;height:38px;border-radius:11px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;color:var(--navy);font-size:20px}.settingcopy{min-width:0}.settingtitle{display:block;font-size:14px;font-weight:800;line-height:1.25}.settingdesc{display:block;margin-top:4px;font-size:12px;color:var(--muted);white-space:nowrap;overflow:hidden;text-overflow:ellipsis}.settingright{display:flex;align-items:center;gap:8px;color:var(--muted);font-size:12px;white-space:nowrap}.chevron{font-size:20px;line-height:1}.statusok{display:inline-flex;align-items:center;gap:5px}.statusok:before{content:'';width:7px;height:7px;border-radius:50%;background:var(--green)}.themebuttons{padding:12px}.themeswitch{position:relative;display:grid;grid-template-columns:1fr 1fr;align-items:center;background:var(--navy);border:1px solid color-mix(in srgb,var(--navy) 72%,white 28%);border-radius:999px;padding:5px;min-height:62px;overflow:hidden;box-shadow:inset 0 0 0 1px rgba(255,255,255,.04)}.themeswitch::before{content:"";position:absolute;top:5px;bottom:5px;left:5px;width:calc(50% - 5px);border-radius:999px;background:var(--orange);box-shadow:0 5px 16px rgba(252,176,49,.34);transition:left .42s cubic-bezier(.22,1,.36,1),box-shadow .3s ease}.themeswitch[data-active="dark"]::before{left:50%}.themeswitch button{position:relative;z-index:1;min-height:52px;border-radius:999px;border:0;background:transparent;color:#d8deea;font-weight:800;font-size:15px;display:flex;align-items:center;justify-content:center;gap:8px;transition:color .25s ease,transform .18s ease}.themeswitch button[aria-pressed="true"]{color:#202838}.themeswitch button:active{transform:scale(.97)}.themeglyph{font-size:17px;line-height:1;transition:transform .35s cubic-bezier(.22,1,.36,1)}.themeswitch button[aria-pressed="true"] .themeglyph{transform:rotate(12deg) scale(1.12)}.walkthroughbtn{width:100%;min-height:54px;border-radius:12px;background:var(--orange);color:var(--ink);font-weight:800;font-size:15px}.guidehero{padding:2px 0 6px}.guideeyebrow{display:inline-flex;align-items:center;gap:6px;font-size:12px;font-weight:800;color:var(--orange);letter-spacing:.2px;margin-bottom:10px}.guidehero h3{font-size:24px;line-height:1.15;margin:0 0 8px}.guidehero p{font-size:14px;line-height:1.55;color:var(--muted);margin:0}.guidecard{background:var(--surface-alt);border:1px solid var(--border);border-radius:16px;padding:14px 14px 12px;margin-top:14px}.guidecard h4{margin:0 0 6px;font-size:15px}.guidecard p{margin:0;color:var(--muted);font-size:13px;line-height:1.5}.guidelist{display:grid;gap:10px;margin-top:14px}.guideitem{display:grid;grid-template-columns:36px 1fr;gap:10px;align-items:start;padding:12px;border:1px solid var(--border);border-radius:14px;background:var(--surface)}.guideitemicon{width:36px;height:36px;border-radius:12px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;font-size:18px;color:var(--navy)}.guideitem b{display:block;font-size:14px;margin-bottom:4px}.guideitem small{display:block;font-size:12px;line-height:1.45;color:var(--muted)}.guideprogress{display:flex;align-items:center;justify-content:space-between;gap:12px;margin-top:16px}.guideprogress small{font-size:12px;color:var(--muted);font-weight:700}.guidedots{display:flex;gap:6px;align-items:center}.guidedot{width:8px;height:8px;border-radius:999px;background:#d9dfeb;transition:all .22s ease}.guidedot.active{width:24px;background:var(--orange)}.guideactions{display:flex;justify-content:flex-end;gap:10px;align-items:center;margin-top:18px}.guidebtn{min-height:46px;padding:0 14px;border-radius:12px;font-weight:800}.guidebtn.secondary{background:var(--surface-alt);color:var(--ink);border:1px solid var(--border)}.guidebtn.primary{background:var(--orange);color:var(--ink)}.guidebtn.ghost{background:transparent;color:var(--muted)}.guideactionstack{display:flex;justify-content:flex-end;gap:10px}.guideinline{display:grid;gap:10px;margin-top:14px}.guidethemeinline{position:relative;display:grid;grid-template-columns:1fr 1fr;background:var(--navy);border:1px solid var(--border);border-radius:999px;padding:5px;min-height:62px;overflow:hidden;margin-top:14px}.guidethemeinline::before{content:"";position:absolute;top:5px;bottom:5px;left:5px;width:calc(50% - 5px);border-radius:999px;background:var(--orange);box-shadow:0 5px 16px rgba(252,176,49,.32);transform:translateX(0);transition:transform .38s cubic-bezier(.22,1,.36,1)}.guidethemeinline[data-active="dark"]::before{transform:translateX(100%)}.guidethemeinline button{position:relative;z-index:1;min-height:52px;border:0;border-radius:999px;background:transparent;font-weight:800;color:#d8deea;display:flex;align-items:center;justify-content:center;gap:8px}.guidethemeinline button.active{color:#202838}.guidecallout{margin-top:14px;padding:12px 14px;border-radius:14px;background:#fff8e8;border:1px solid #f3d182;color:#5d4a15;font-size:12px;line-height:1.5}.modalaction{width:100%;margin-top:12px;min-height:48px;border-radius:11px;background:var(--orange);color:var(--ink);font-weight:800}.modalinfo{display:grid;gap:10px;margin-top:10px}.modalinforow{display:flex;justify-content:space-between;gap:12px;padding:11px 0;border-bottom:1px solid var(--border);font-size:13px}.modalinforow:last-child{border-bottom:0}.modalinforow span:last-child{font-weight:800;text-align:right}
.dataviewmeta{display:flex;flex-wrap:wrap;gap:8px;margin:0 0 14px}
.dataviewchip{font-size:12px;color:var(--muted);background:var(--surface-alt);border:1px solid var(--border);border-radius:999px;padding:7px 10px}
.datatablewrap{width:100%;overflow:auto;border:1px solid var(--border);border-radius:14px;background:var(--surface);max-height:52dvh;-webkit-overflow-scrolling:touch}
.datatable{width:100%;border-collapse:separate;border-spacing:0;min-width:760px;font-size:12px;font-variant-numeric:tabular-nums}
.datatable th{position:sticky;top:0;z-index:2;background:var(--navy);color:#fff;text-align:left;padding:11px 10px;font-size:11px;letter-spacing:.15px;white-space:nowrap}
.datatable td{padding:10px;border-bottom:1px solid var(--border);white-space:nowrap;color:var(--ink)}
.datatable tbody tr:last-child td{border-bottom:0}
.datatable tbody tr:nth-child(even){background:var(--surface-alt)}
.datatable .num{text-align:right}
.datatableempty{padding:26px 18px;text-align:center;color:var(--muted);font-size:13px}
.dataviewfooter{display:flex;align-items:center;justify-content:space-between;gap:10px;margin-top:12px}
.dataviewfooter small{color:var(--muted);font-size:11px;line-height:1.35}
.dataviewfooter .modalaction{width:auto;margin:0;padding:0 16px}
@media(max-width:420px){
  .datatablewrap{max-height:48dvh;border-radius:12px}
  .datatable{font-size:11px;min-width:700px}
  .datatable th,.datatable td{padding:9px 8px}
  .dataviewfooter{align-items:flex-start;flex-direction:column}
  .dataviewfooter .modalaction{width:100%}
}
.modaloverlay{position:fixed;inset:0;z-index:30;background:#142035aa;display:none;align-items:center;justify-content:center;padding:15px}.modaloverlay.open{display:flex}.modal{background:white;border-radius:19px;padding:20px;width:min(100%,470px);max-height:88dvh;overflow:auto}.modal header{display:flex;justify-content:space-between;align-items:center}.modal h2{font-size:20px}.modal .close{background:none;font-size:23px;color:var(--ink)}.modal section{padding:14px 0;border-top:1px solid #e7ebf0}.modal section p{font-size:13px;color:var(--muted);line-height:1.5}.options{display:grid;gap:8px}.option{display:block;width:100%;border:2px solid #e2e7ef;background:white;border-radius:13px;padding:13px;text-align:left;color:var(--ink)}.option.selected{border-color:var(--orange);background:#fff5de}.option small{display:block;color:var(--muted);margin-top:5px}.hint{border-radius:10px;background:#f0f3f8;padding:11px;font-size:12px;line-height:1.5;color:#475569;margin-top:10px}.toast{position:fixed;bottom:calc(90px + env(safe-area-inset-bottom));left:50%;transform:translateX(-50%);z-index:45;background:var(--navy);color:white;border-radius:12px;padding:12px 17px;display:none;max-width:90%;text-align:center}.toast.show{display:block}

/* Meetpagina: consistente binnenmarges en uitlijning van sensortegels */
.measuregrid{gap:12px;grid-template-columns:repeat(2,minmax(0,1fr))}
.measuregrid .tile{padding:18px 16px;min-height:116px;gap:13px;align-items:center;min-width:0}
.measuregrid .tile .symbol{flex:0 0 29px;width:29px;text-align:center;font-size:25px;line-height:1}
.measuregrid .tile>div{flex:1;min-width:0}
.measuregrid .tile .label{font-size:15px;line-height:1.35;margin-bottom:7px}
.measuregrid .tile .value{font-size:20px;line-height:1.22;margin:0 0 8px;overflow-wrap:break-word}
.measuregrid .tile .sub{font-size:14px;line-height:1.35;margin:0}
@media(max-width:370px){.measuregrid{gap:9px}.measuregrid .tile{padding:15px 11px;gap:8px}.measuregrid .tile .symbol{flex-basis:23px;width:23px;font-size:22px}.measuregrid .tile .label{font-size:14px}.measuregrid .tile .value{font-size:18px}.measuregrid .tile .sub{font-size:13px}}

/* DataLogger: twee volledig werkende, opgeslagen thema's. */
:root {color-scheme:light;--bg:#E9E9E9;--ink:#232323;--muted:#526075;--navy:#343F58;--orange:#FCB031;--surface:#FFFFFF;--surface-alt:#F1F3F6;--border:#DCE2EB;--shadow:rgba(35,35,35,.09);--button-text:#FFFFFF}
:root[data-theme="dark"] {color-scheme:dark;--bg:#232323;--ink:#FFFFFF;--muted:#C0CAD8;--navy:#343F58;--orange:#FCB031;--surface:#30394B;--surface-alt:#283246;--border:#4B5870;--shadow:rgba(0,0,0,.22);--button-text:#FFFFFF}
body,.app{background:var(--bg);color:var(--ink)}
.content,.sheet,.panel,.sensor,.tile,.sd,.modal{background:var(--surface);color:var(--ink)}
.sensor,.tile,.sd,.location,.option{border-color:var(--border);box-shadow:0 2px 8px var(--shadow)}
.settingrow,.hint,.state,.option{background:var(--surface-alt);color:var(--ink)}
.settingrow button{background:var(--border);color:var(--ink)}
.label,.option small,.locationaside small,.meta,.sub,.settingrow small{color:var(--muted)}
.file,.modal section{border-color:var(--border)}
#settings .panel button[onclick="openModal('about')"]{background:var(--surface)!important;color:var(--ink);border:1px solid var(--border);border-radius:11px}
.action.start,.startbtn,.pause{background:var(--orange);color:#232323}
.action.data,.continue,.file button{background:var(--navy);color:#FFFFFF}
.stop{background:var(--red);color:#FFFFFF}
.hero{background:linear-gradient(130deg,#253044 20%,#657a90 65%,#f3d2b6);color:#FFFFFF}
.system{background:var(--surface);color:var(--ink)}
.nav,.top{background:var(--navy);color:#FFFFFF}
.nav button{color:#E9E9E9}.nav button.selected{color:var(--orange)}
:root[data-theme="dark"] .pill{background:#214C3A;color:#A5E6C0}
:root[data-theme="dark"] .locationaside p{color:#87BEFF}
:root[data-theme="dark"] .map{background:linear-gradient(140deg,#244B3C 0%,#304B42 45%,#224457 46%,#31546A 70%,#305041 71%)}
:root[data-theme="dark"] .option.selected{background:#554526;border-color:var(--orange)}
:root[data-theme="dark"] .sd .arrow{color:var(--muted)}
:root[data-theme="dark"] #badge{color:#232323}
@media(prefers-reduced-motion:reduce){*,*:before,*:after{scroll-behavior:auto!important;transition:none!important;animation:none!important}}

/* Mobile-first interval sheet */
.modal:has(#intervalChoices){width:min(100%,520px);padding:clamp(20px,5vw,30px);border-radius:24px;max-height:calc(100dvh - 32px);overflow-y:auto}
.interval-intro{color:var(--muted);line-height:1.5;margin:0 0 19px}
.interval-choices{display:grid;grid-template-columns:repeat(4,minmax(0,1fr));gap:10px;margin:16px 0 21px}
.interval-choice{background:var(--surface-alt);border:2px solid var(--border);border-radius:15px;min-height:80px;padding:10px 5px;color:var(--ink);display:flex;flex-direction:column;align-items:center;justify-content:center;gap:5px;font-weight:800;font-size:20px;transition:border-color .12s,background .12s}
.interval-choice small{font-size:12px;font-weight:500;color:var(--muted)}
.interval-choice[aria-pressed="true"]{border-color:var(--orange);background:color-mix(in srgb,var(--orange) 13%,var(--surface));box-shadow:inset 0 0 0 1px var(--orange)}
.interval-help{border-radius:12px;background:var(--surface-alt);padding:13px 15px;color:var(--muted);line-height:1.45;font-size:13px;margin-bottom:20px}
.interval-save{width:100%;min-height:56px;font-weight:800;font-size:16px;border-radius:14px}
@media(max-width:360px){.interval-choices{gap:7px}.interval-choice{min-height:72px;font-size:20px}}
/* Custom interval selection */
.interval-custom{display:flex;align-items:center;gap:12px;border:2px solid var(--border);border-radius:15px;padding:14px 16px;background:var(--surface-alt);margin:-5px 0 15px;min-height:76px}
.interval-custom:focus-within,.interval-custom.selected{border-color:var(--orange);box-shadow:inset 0 0 0 1px var(--orange)}
.interval-custom label{flex:1;font-weight:700;color:var(--ink);line-height:1.35}
.interval-custom label small{display:block;color:var(--muted);font-size:12px;font-weight:400;margin-top:4px}
.interval-custom input{width:92px;min-width:0;min-height:48px;border:1px solid var(--border);border-radius:10px;background:var(--surface);color:var(--ink);text-align:center;font-size:22px;font-weight:800;padding:8px}
.interval-error{color:#dc2626;min-height:18px;font-size:13px;margin:0 0 10px}
@media(max-width:360px){.interval-custom{padding:11px;gap:8px}.interval-custom input{width:78px}}

/* Meetpagina iconen: één kleur, licht/donker thema */
:root{--measure-icon:#253044}
:root[data-theme="dark"]{--measure-icon:#FFFFFF}
.measuregrid .tile .symbol{color:var(--measure-icon)!important}
.measuregrid .tile .symbol svg *{stroke:currentColor!important;fill:none!important}
.measuregrid .tile .symbol svg circle,.measuregrid .tile .symbol svg .fill-icon{fill:currentColor!important;stroke:none!important}

/* Meetpagina: zelfde 1/3 icoon + 2/3 content styling als dashboard, zonder dashboard te wijzigen */
.measuregrid{display:grid;grid-template-columns:1fr 1fr;gap:14px}
.measuregrid .tile{position:relative;border:1px solid var(--border);border-radius:18px;padding:0;background:var(--surface);box-shadow:0 8px 20px var(--shadow);display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:132px;overflow:hidden}
.measuregrid .tile .tileicon{display:flex;align-items:center;justify-content:center;padding:18px}
.measuregrid .tile .tileicon .iconwrap{width:58px;height:58px;flex:0 0 58px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}
:root[data-theme="dark"] .measuregrid .tile .tileicon .iconwrap{background:rgba(255,255,255,.06)}
.measuregrid .tile .tilecontent{display:flex;flex-direction:column;justify-content:center;padding:18px 16px 18px 6px;min-width:0}
.measuregrid .tile .label{font-size:12px;margin-bottom:6px}
.measuregrid .tile .value{font-size:17px;font-weight:800;line-height:1.15;margin:0 0 8px;overflow-wrap:anywhere}
.measuregrid .tile .sub{font-size:14px;line-height:1.35;margin:0}
.measuregrid .tile .symbol{display:flex;align-items:center;justify-content:center}
.measuregrid .tile .symbol svg{width:30px;height:30px}
@media(max-width:380px){.measuregrid{grid-template-columns:1fr}.measuregrid .tile{min-height:118px}}

/* Grafiekenpagina */
.chartwrap{padding:17px}.chartwrap h1{font-size:23px;margin:0 0 5px}.chartintro{font-size:13px;color:var(--muted);margin:0 0 16px}.chartpanel{background:var(--surface);border:1px solid var(--border);border-radius:17px;padding:16px;margin-bottom:13px;box-shadow:0 5px 16px var(--shadow)}
.chartlabel{display:block;font-size:12px;color:var(--muted);margin-bottom:8px}.chartselect{width:100%;border:1px solid var(--border);background:var(--surface-alt);color:var(--ink);border-radius:12px;padding:13px 14px;font-weight:700;min-height:48px}.metricbuttons{display:grid;grid-template-columns:1fr 1fr;gap:8px}.metricbuttons button{min-height:46px;border-radius:11px;background:var(--surface-alt);color:var(--ink);border:1px solid var(--border);font-weight:700}.metricbuttons button.active{background:var(--orange);border-color:var(--orange);color:#232323}.charthead{display:flex;align-items:flex-start;justify-content:space-between;gap:12px;margin-bottom:10px}.charthead h2{margin:0;font-size:17px}.chartvalue{text-align:right}.chartvalue strong{display:block;font-size:23px;line-height:1}.chartvalue small{color:var(--muted);font-size:11px}.chartbox{position:relative;height:265px;border-radius:13px;background:var(--surface-alt);overflow:hidden;border:1px solid var(--border);display:grid;grid-template-columns:48px 1fr}.chartyaxis{position:relative;z-index:2;background:var(--surface-alt);border-right:1px solid var(--border);overflow:hidden}.chartyaxis svg{width:48px;height:100%;display:block}.chartscroll{min-width:0;overflow-x:auto;overflow-y:hidden;-webkit-overflow-scrolling:touch;touch-action:pan-x}.chartscroll svg{height:100%;display:block;max-width:none}.chartscroll::-webkit-scrollbar{height:5px}.chartscroll::-webkit-scrollbar-thumb{background:var(--border);border-radius:999px}.chart-empty{height:245px;display:flex;align-items:center;justify-content:center;text-align:center;color:var(--muted);font-size:13px;padding:30px}.chartgridline{stroke:var(--border);stroke-width:1}.chartline{fill:none;stroke:var(--orange);stroke-width:3;stroke-linecap:round;stroke-linejoin:round}.chartarea{fill:var(--orange);opacity:.10}.chartdot{fill:var(--orange);stroke:var(--surface);stroke-width:2}.chartaxis{fill:var(--muted);font-size:10px}.chartstats{display:grid;grid-template-columns:repeat(3,1fr);gap:8px;margin-top:12px}.chartstat{background:var(--surface-alt);border-radius:11px;padding:10px;text-align:center}.chartstat small{display:block;color:var(--muted);font-size:10px;margin-bottom:4px}.chartstat strong{font-size:14px}.chartnote{font-size:11px;color:var(--muted);line-height:1.45;margin-top:10px}
.manualdoc{font-size:13px;line-height:1.55;color:var(--ink)}
.manualdoc .manualhero{background:var(--navy);color:#fff;border-radius:14px;padding:16px;margin-bottom:14px}
.manualdoc .manualhero b{display:block;font-size:18px;margin-bottom:4px}.manualdoc .manualhero small{color:#dbe2ef}
.manualdoc h3{font-size:15px;margin:18px 0 6px}.manualdoc p{margin:6px 0 10px;color:var(--muted)}
.manualdoc .manualgrid{display:grid;grid-template-columns:1fr 1fr;gap:8px}.manualdoc .manualcard{background:var(--surface-alt);border:1px solid var(--border);border-radius:11px;padding:10px}
.manualdoc .manualcard b{display:block;margin-bottom:3px}.manualdoc .manualcard small{color:var(--muted);line-height:1.4}
.manualdoc .manualtable{width:100%;border-collapse:collapse;margin:8px 0}.manualdoc .manualtable td,.manualdoc .manualtable th{padding:8px;border-bottom:1px solid var(--border);text-align:left;font-size:12px}
.manualdoc .manualcallout{background:color-mix(in srgb,var(--orange) 14%,var(--surface));border-left:4px solid var(--orange);padding:10px 11px;border-radius:9px;margin:10px 0}
.manualdoc .manualsteps{display:grid;gap:7px}.manualdoc .manualstep{display:flex;gap:9px;background:var(--surface-alt);border-radius:10px;padding:9px}.manualdoc .manualnum{flex:0 0 24px;height:24px;border-radius:7px;background:var(--orange);display:grid;place-items:center;font-weight:800;color:#232323}
.manualactions{display:grid;grid-template-columns:1fr;gap:8px;margin-top:16px}.manualactions button{min-height:44px;border-radius:12px;font-weight:800}.manualpdf{background:var(--orange);color:#232323}.manualclose{background:var(--surface-alt);color:var(--ink);border:1px solid var(--border)}
@media(max-width:430px){.manualdoc .manualgrid{grid-template-columns:1fr}}
.nav .chartNavIcon{font-size:33px;font-weight:700;letter-spacing:-2px}

@media (prefers-reduced-motion:reduce){.themeswitch::before,.themeswitch button,.themeglyph{transition:none!important}}

/* Data page theme repair — layout untouched */
#data .overviewcard,#data .sessionlist,#data .filterpanel{background:var(--surface);border-color:var(--border);color:var(--ink)}
#data .sessionrow{border-color:var(--border)}
#data .periodpill,#data .searchbox,#data .filterbtn,#data .filteroption,#data .fileicon{background:var(--surface-alt);border-color:var(--border);color:var(--ink)}
#data .searchbox input{color:var(--ink)}
#data .searchbox input::placeholder{color:var(--muted);opacity:1}
#data .overviewvalue,#data .sectionhead,#data .sessiontitle,#data .filterlabel{color:var(--ink)}
#data .overviewlabel,#data .sessionmeta,#data .sessionsub,#data .periodpill{color:var(--muted)}
#data .miniicon,#data .fileicon{color:var(--ink)}
#data .filterbtn.active,#data .filteroption.active{border-color:var(--orange);background:color-mix(in srgb,var(--orange) 18%,var(--surface));color:var(--ink)}
#data .csvbtn{background:var(--orange);color:#232323}
:root[data-theme="dark"] #data .overviewcard,:root[data-theme="dark"] #data .sessionlist,:root[data-theme="dark"] #data .filterpanel{box-shadow:0 2px 10px rgba(0,0,0,.18)}


/* Mobile responsiveness improvements */
@media (max-width: 430px){
  .app{max-width:100%;}
  .top{padding:calc(env(safe-area-inset-top) + 12px) 14px 12px;min-height:64px}
  .brand{font-size:21px}
  .top button{font-size:24px;padding:2px 5px}
  .datawrap{padding:14px 12px calc(128px + env(safe-area-inset-bottom))}
  .datatop{align-items:center;margin-bottom:12px}
  .datatop h1{font-size:17px}
  .periodpill{padding:8px 10px;font-size:11px;border-radius:10px}
  .overviewgrid{grid-template-columns:1fr 1fr;gap:10px;margin-bottom:18px}
  .overviewcard{padding:12px;min-height:104px}
  .overviewcard:nth-child(3){grid-column:1 / -1;display:grid;grid-template-columns:auto 1fr;column-gap:10px;align-items:center;min-height:82px}
  .overviewcard:nth-child(3) .overviewiconrow{grid-row:1 / span 2;margin:0}
  .overviewcard:nth-child(3) .overviewvalue{align-self:end;margin:0}
  .overviewcard:nth-child(3) .overviewlabel{align-self:start}
  .overviewvalue{font-size:25px}
  .overviewlabel{font-size:11px}
  .sectionhead{font-size:17px;margin-bottom:10px}
  .filetoolbar{display:grid;grid-template-columns:1fr auto;gap:8px;margin-bottom:10px}
  .searchbox{height:42px;border-radius:11px;padding:0 11px;min-width:0}
  .searchbox input{font-size:13px}
  .filterbtn{height:42px;border-radius:11px;padding:0 12px;font-size:13px;white-space:nowrap}
  .filterpanel{margin-top:0}
  .sessionlist{border-radius:15px}
  .sessionrow{grid-template-columns:36px minmax(0,1fr) auto;gap:10px;padding:14px 12px;align-items:center}
  .fileicon{width:36px;height:36px;border-radius:10px}
  .fileicon svg{width:19px;height:19px}
  .sessiontitle{font-size:13px;margin-bottom:4px;white-space:normal;overflow-wrap:anywhere}
  .sessionmeta,.sessionsub{font-size:11px;line-height:1.4}
  .csvbtn{height:34px;padding:0 10px;font-size:11px;border-radius:9px;gap:5px}
  .csvbtn svg{width:13px;height:13px}
  .nav{width:100%;border-radius:14px 14px 0 0;padding:8px 0 calc(22px + env(safe-area-inset-bottom))}
  .nav button{min-height:52px;padding:4px 0}
  .nav button span{font-size:29px}
  .nav button .homeNavIcon{font-size:34px}
  .nav button .chartNavIcon{height:28px;width:32px}
}
@media (max-width: 360px){
  .overviewgrid{grid-template-columns:1fr;}
  .overviewcard:nth-child(3){grid-column:auto;display:block;min-height:96px}
  .overviewcard:nth-child(3) .overviewiconrow{margin-bottom:7px}
  .filetoolbar{grid-template-columns:1fr}
  .filterbtn{width:100%;justify-content:center}
  .sessionrow{grid-template-columns:32px minmax(0,1fr);}
  .fileicon{width:32px;height:32px}
  .csvbtn{grid-column:2;justify-self:start;margin-top:7px}
}

/* FINAL mobile override: keep all three overview tiles in one row */
@media (max-width:520px){
  #data .overviewgrid{
    display:grid!important;
    grid-template-columns:repeat(3,minmax(0,1fr))!important;
    gap:7px!important;
  }
  #data .overviewcard,
  #data .overviewcard:nth-child(3){
    grid-column:auto!important;
    display:block!important;
    min-width:0!important;
    min-height:88px!important;
    padding:9px 7px!important;
  }
  #data .overviewcard:nth-child(3) .overviewiconrow{
    grid-row:auto!important;
    margin-bottom:5px!important;
  }
  #data .overviewiconrow{
    min-height:14px!important;
    margin-bottom:5px!important;
  }
  #data .miniicon,#data .miniicon svg{width:14px!important;height:14px!important;}
  #data .overviewvalue{
    font-size:16px!important;
    line-height:1.05!important;
    margin-bottom:3px!important;
    white-space:normal!important;
    overflow-wrap:anywhere!important;
  }
  #data .overviewlabel{
    font-size:9.5px!important;
    line-height:1.1!important;
    white-space:normal!important;
  }
}
@media (max-width:350px){
  #data .overviewgrid{gap:5px!important;}
  #data .overviewcard,#data .overviewcard:nth-child(3){padding:8px 6px!important;min-height:84px!important;}
  #data .overviewvalue{font-size:15px!important;}
  #data .overviewlabel{font-size:9px!important;}
}

/* Verbindingshulp wanneer de Arduino niet meer bereikbaar is */
.connectionlost{position:fixed;inset:0;z-index:100;background:var(--bg);color:var(--ink);display:none;overflow:auto;padding:calc(env(safe-area-inset-top) + 20px) 16px calc(env(safe-area-inset-bottom) + 28px)}
.connectionlost.show{display:block}
.connectionlost-inner{width:min(100%,520px);margin:0 auto}
.connectionlost-brand{font-size:22px;font-weight:800;color:var(--ink);margin-bottom:34px}.connectionlost-brand span{color:var(--orange)}
.connectionlost-icon{width:72px;height:72px;border-radius:22px;background:var(--surface);border:1px solid var(--border);display:flex;align-items:center;justify-content:center;margin:0 0 20px;box-shadow:0 8px 24px var(--shadow);color:var(--navy)}
.connectionlost-icon svg{width:38px;height:38px}
.connectionlost h1{font-size:25px;line-height:1.18;margin:0 0 12px}
.connectionlost>div p,.connectionlost-inner>p{color:var(--muted);font-size:14px;line-height:1.55;margin:0 0 20px}
.connectionchecklist{display:grid;gap:10px;margin:20px 0}
.connectioncheck{display:grid;grid-template-columns:38px 1fr;gap:12px;align-items:start;background:var(--surface);border:1px solid var(--border);border-radius:16px;padding:14px;box-shadow:0 3px 12px var(--shadow)}
.connectioncheck-num{width:38px;height:38px;border-radius:12px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;font-weight:800;color:var(--navy)}
.connectioncheck b{display:block;font-size:14px;margin:1px 0 4px}.connectioncheck small{display:block;color:var(--muted);font-size:12px;line-height:1.45}
.connectionwifi{background:color-mix(in srgb,var(--orange) 13%,var(--surface));border:1px solid color-mix(in srgb,var(--orange) 48%,var(--border));border-radius:14px;padding:13px 14px;margin:14px 0;font-size:13px;line-height:1.5}
.connectionwifi code{font-family:inherit;font-weight:800;color:var(--ink)}
.connectionactions{display:grid;grid-template-columns:1fr 1fr;gap:10px;margin-top:18px}
.connectionactions button{min-height:52px;border-radius:13px;font-weight:800;padding:0 12px}
.connectionretry{background:var(--orange);color:#232323}.connectionreload{background:var(--surface-alt);color:var(--ink);border:1px solid var(--border)}
.connectionstate{font-size:12px;color:var(--muted);text-align:center;margin-top:12px;min-height:18px}
@media(max-width:360px){.connectionactions{grid-template-columns:1fr}.connectionlost h1{font-size:23px}}

/* ===== Dashboard UI polish ===== */
:root{
  --radius-sm:12px;
  --radius-md:16px;
  --radius-lg:20px;
}

/* Compactere app-header */
.top{
  min-height:68px;
  padding:calc(env(safe-area-inset-top) + 12px) 16px 12px;
}
.brand{font-size:22px}
.topGearBtn{
  width:42px;
  height:42px;
  padding:0!important;
  border-radius:12px;
  display:flex;
  align-items:center;
  justify-content:center;
}
.topGearIcon{width:25px;height:25px;display:block}

/* Minder hoge hero zodat de primaire acties sneller zichtbaar zijn */
.hero{
  height:148px;
  padding:20px 18px;
}
.hero h1{
  font-size:23px;
  line-height:1.1;
}
.hero p{
  margin-top:12px;
  font-size:15px;
}
.hero:after{
  height:64px;
  bottom:18px;
}

/* Compactere systeemstatus */
.system{
  left:14px;
  right:14px;
  padding:9px 12px;
  border-radius:14px 14px 0 0;
  font-size:11px;
  align-items:center;
}
.system .dot{
  width:8px;
  height:8px;
  margin-right:6px;
}

/* Meer balans in primaire dashboardtiles */
.content{
  padding:14px;
}
.homeactions{
  gap:12px;
}
.action{
  min-height:122px;
  border-radius:var(--radius-lg);
  padding:15px 10px;
  gap:9px;
}
.action strong{
  font-size:15px;
  line-height:1.2;
}
.action small{
  font-size:11px;
  line-height:1.35;
  opacity:.9;
}
.action .bigicon{
  width:46px;
  height:46px;
}
.action .bigicon svg{
  width:27px;
  height:27px;
}
.playIconWrap,
.dataIconWrap{
  border-radius:14px;
  display:flex;
  align-items:center;
  justify-content:center;
}
.playIconWrap{
  background:rgba(35,35,35,.14);
  color:#232323;
}
.dataIconWrap{
  background:rgba(255,255,255,.12);
  color:#fff;
}
.actionDataIcon{display:block}

/* Rustigere sectiekop */
.sectiontitle{
  margin:20px 3px 12px;
}
.sectiontitle h2{
  font-size:18px;
}
.live{
  font-size:12px;
}
.live .dot{
  width:8px;
  height:8px;
}

/* Sensorcards: meer ruimte voor de meetwaarde */
.sensors{
  gap:12px;
}
.sensor{
  grid-template-columns:28% 72%;
  min-height:134px;
  border-radius:var(--radius-md);
}
.sensor.compact{
  min-height:124px;
}
.sensoricon{
  padding:14px 10px;
}
.sensoricon .iconwrap{
  width:56px;
  height:56px;
  flex-basis:56px;
  border-radius:14px;
}
.sensorcontent{
  padding:15px 15px 15px 7px;
}
.sensor .label{
  font-size:11px;
  margin-bottom:5px;
}
.sensor .value,
.sensor.emphasis .value{
  font-size:19px;
}
.sensor.compact .value{
  font-size:17px;
}
.sensor .sub{
  font-size:11px;
  margin-top:7px;
  line-height:1.3;
}

/* SD-card in dezelfde visuele familie */
.sd{
  border-radius:var(--radius-md);
  margin-top:12px;
}
.sd .sensoricon .iconwrap{
  width:52px;
  height:52px;
  border-radius:14px;
}

/* Compactere bottom navigation */
.page{
  padding-bottom:calc(100px + env(safe-area-inset-bottom));
}
.nav{
  border-radius:18px 18px 0 0;
  padding:7px 8px calc(14px + env(safe-area-inset-bottom));
  min-height:78px;
  gap:4px;
}
.nav button{
  min-height:48px;
  padding:4px 0;
  border-radius:14px;
  position:relative;
}
.nav button span{
  font-size:0;
}
.navIconWrap,
.nav button>span{
  width:38px;
  height:38px;
  display:flex;
  align-items:center;
  justify-content:center;
  border-radius:12px;
  transition:background .2s ease,color .2s ease,transform .18s ease;
}
.navSvgIcon,
.nav .playIconSvg{
  width:25px;
  height:25px;
}
.nav button .chartNavIcon{
  width:38px;
  height:38px;
  gap:3px;
  align-items:flex-end;
  padding:7px 8px;
}
.nav button .chartNavIcon i{
  width:5px;
}
.nav button.selected>span{
  background:rgba(252,176,49,.14);
}
.nav button.selected{
  color:var(--orange);
}
.nav button:active>span{
  transform:scale(.94);
}

/* iets meer witruimte onder de laatste dashboardcards */
#home .content{
  padding-bottom:24px;
}

/* Alle iconen op mobiel beter in verhouding */
@media(max-width:430px){
  .top{
    min-height:62px;
    padding:calc(env(safe-area-inset-top) + 9px) 14px 9px;
  }
  .brand{font-size:20px}
  .topGearBtn{width:38px;height:38px}
  .topGearIcon{width:23px;height:23px}

  .hero{
    height:132px;
    padding:18px 16px;
  }
  .hero h1{font-size:22px}
  .hero p{font-size:14px;margin-top:10px}

  .system{
    left:12px;
    right:12px;
    padding:8px 10px;
    font-size:10px;
  }

  .content{padding:12px}
  .homeactions{gap:10px}
  .action{
    min-height:112px;
    padding:13px 8px;
    border-radius:18px;
  }
  .action .bigicon{
    width:42px;
    height:42px;
  }
  .action .bigicon svg{
    width:25px;
    height:25px;
  }

  .sensor{
    min-height:126px;
  }
  .sensor.compact{
    min-height:116px;
  }
  .sensoricon .iconwrap{
    width:52px;
    height:52px;
    flex-basis:52px;
  }
  .sensorcontent{
    padding:13px 12px 13px 6px;
  }
  .sensor .value,
  .sensor.emphasis .value{
    font-size:18px;
  }
  .sensor.compact .value{
    font-size:16px;
  }

  .nav{
    min-height:70px;
    padding:6px 8px calc(10px + env(safe-area-inset-bottom));
  }
  .nav button{
    min-height:46px;
  }
  .navIconWrap,
  .nav button>span{
    width:36px;
    height:36px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:24px;
    height:24px;
  }
  .nav button .chartNavIcon{
    width:36px;
    height:36px;
  }
}

/* Op zeer smalle telefoons blijven sensorcards 2 naast elkaar, maar compacter */
@media(max-width:380px){
  #home .sensors{
    grid-template-columns:1fr 1fr;
    gap:9px;
  }
  #home .sensor{
    min-height:118px;
    grid-template-columns:29% 71%;
  }
  #home .sensoricon{
    padding:10px 5px;
  }
  #home .sensoricon .iconwrap{
    width:44px;
    height:44px;
    flex-basis:44px;
  }
  #home .sensorcontent{
    padding:10px 8px 10px 4px;
  }
  #home .sensor .label{
    font-size:10px;
  }
  #home .sensor .value,
  #home .sensor.emphasis .value{
    font-size:16px;
  }
  #home .sensor.compact .value{
    font-size:15px;
  }
  #home .sensor .sub{
    font-size:9.5px;
  }
}

/* ===== Compacte sticky topbar + kleinere onderruimte ===== */

/* Kleur de iOS safe-area bovenaan hetzelfde als de header */
html{
  background:var(--navy);
}
body{
  background:var(--bg);
}
body::before{
  content:"";
  position:fixed;
  top:0;
  left:0;
  right:0;
  height:env(safe-area-inset-top);
  background:var(--navy);
  z-index:49;
  pointer-events:none;
}

/* Header blijft zichtbaar tijdens scrollen */
.top{
  position:sticky;
  top:0;
  z-index:50;
  min-height:56px;
  padding:calc(env(safe-area-inset-top) + 6px) 14px 7px;
  box-shadow:0 2px 8px rgba(0,0,0,.08);
}
.brand{
  font-size:20px;
  line-height:1;
}
.topGearBtn{
  width:36px;
  height:36px;
}
.topGearIcon{
  width:22px;
  height:22px;
}

/* Minder ruimte onderaan de app */
.page{
  padding-bottom:calc(76px + env(safe-area-inset-bottom));
}
.nav{
  min-height:62px;
  padding:4px 8px calc(5px + env(safe-area-inset-bottom));
}
.nav button{
  min-height:42px;
  padding:2px 0;
}
.navIconWrap,
.nav button>span{
  width:34px;
  height:34px;
}
.navSvgIcon,
.nav .playIconSvg{
  width:23px;
  height:23px;
}
.nav button .chartNavIcon{
  width:34px;
  height:34px;
  padding:6px 7px;
}

/* De laatste content hoeft niet zo ver boven de navigatie te stoppen */
#home .content{
  padding-bottom:14px;
}

/* Mobiel nog compacter */
@media(max-width:430px){
  .top{
    min-height:54px;
    padding:calc(env(safe-area-inset-top) + 5px) 12px 6px;
  }
  .brand{font-size:19px}
  .topGearBtn{width:34px;height:34px}
  .topGearIcon{width:21px;height:21px}

  .page{
    padding-bottom:calc(70px + env(safe-area-inset-bottom));
  }
  .nav{
    min-height:58px;
    padding:3px 8px calc(4px + env(safe-area-inset-bottom));
  }
  .nav button{
    min-height:40px;
  }
  .navIconWrap,
  .nav button>span{
    width:32px;
    height:32px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:22px;
    height:22px;
  }
  .nav button .chartNavIcon{
    width:32px;
    height:32px;
  }
}

/* ===== Iets grotere topbar en menu-iconen ===== */
.top{
  min-height:64px;
  padding:calc(env(safe-area-inset-top) + 8px) 16px 9px;
}
.brand{
  font-size:22px;
}
.topGearBtn{
  width:42px;
  height:42px;
}
.topGearIcon{
  width:25px;
  height:25px;
}

/* Grotere iconen in onderste navigatie, zonder de balk weer veel hoger te maken */
.nav button{
  min-height:44px;
}
.navIconWrap,
.nav button>span{
  width:40px;
  height:40px;
}
.navSvgIcon,
.nav .playIconSvg{
  width:28px;
  height:28px;
}
.nav button .chartNavIcon{
  width:40px;
  height:40px;
  padding:6px 7px;
}
.nav button .chartNavIcon i{
  width:5.5px;
}

/* Actieve achtergrond iets ruimer zodat grote iconen niet krap ogen */
.nav button.selected>span{
  border-radius:13px;
}

/* Mobiel */
@media(max-width:430px){
  .top{
    min-height:62px;
    padding:calc(env(safe-area-inset-top) + 7px) 14px 8px;
  }
  .brand{
    font-size:21px;
  }
  .topGearBtn{
    width:40px;
    height:40px;
  }
  .topGearIcon{
    width:24px;
    height:24px;
  }

  .nav button{
    min-height:43px;
  }
  .navIconWrap,
  .nav button>span{
    width:39px;
    height:39px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:27px;
    height:27px;
  }
  .nav button .chartNavIcon{
    width:39px;
    height:39px;
    padding:6px 7px;
  }
}
</style></head><body><div class="app"><header class="top"><div class="brand">Data<span>Logger</span></div><button class="topGearBtn" aria-label="Instellingen openen" onclick="navigate('settings')"><svg class="topGearIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><path d="M12 8.3a3.7 3.7 0 1 0 0 7.4 3.7 3.7 0 0 0 0-7.4Z" stroke="currentColor" stroke-width="1.8"/><path d="M19 13.1v-2.2l-2-.7a7.8 7.8 0 0 0-.8-1.9l.9-1.9-1.6-1.6-1.9.9a7.8 7.8 0 0 0-1.9-.8L11 3H8.9l-.7 2a7.8 7.8 0 0 0-1.9.8l-1.9-.9-1.6 1.6.9 1.9a7.8 7.8 0 0 0-.8 1.9l-2 .7v2.2l2 .7c.2.7.5 1.3.8 1.9l-.9 1.9 1.6 1.6 1.9-.9c.6.3 1.2.6 1.9.8l.7 2H11l.7-2c.7-.2 1.3-.5 1.9-.8l1.9.9 1.6-1.6-.9-1.9c.3-.6.6-1.2.8-1.9l2-.8Z" stroke="currentColor" stroke-width="1.6" stroke-linecap="round" stroke-linejoin="round"/></svg></button></header>
<section id="home" class="page current"><div class="hero"><h1>Welkom terug!</h1><p>Klaar om te meten?</p><div class="system"><span><span class="dot"></span>Systeem online</span><span id="systemSensors">Sensorstatus laden...</span></div></div><div class="content"><div class="homeactions"><button class="action start" onclick="navigate('measure')"><span class="bigicon playIconWrap" aria-hidden="true"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span><strong>Begin met meten</strong><small>Start een nieuwe sessie</small></button><button class="action data" onclick="navigate('data')"><span class="bigicon dataIconWrap" aria-hidden="true"><svg class="actionDataIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><rect x="5" y="4" width="14" height="16" rx="2.5" stroke="currentColor" stroke-width="1.8"/><path d="M8 8h8M8 12h8M8 16h5" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/></svg></span><strong>Bekijk je data</strong><small>Ga naar opgeslagen metingen</small></button></div><div class="sectiontitle"><h2>Status</h2><span class="live"><span class="dot"></span>Actief</span></div><div class="sensors"><article class="sensor emphasis"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M9 8.5a3 3 0 0 1 6 0v4a3 3 0 0 1-6 0v-4Z" stroke="#F2A51A" stroke-width="1.8"/><path d="M6.5 12.5a5.5 5.5 0 0 0 11 0M12 18v3M9.5 21h5" stroke="#F2A51A" stroke-width="1.8" stroke-linecap="round"/></svg></span></span></div><div class="sensorcontent"><div class="label">Geluidssensor</div><div class="value" id="homeSoundRaw">Controleren...</div><div class="sub">MAX4466 · 10 metingen/s</div></div></article><article class="sensor compact"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3.8 6.2 8.8 4l6.4 2.1 5-2.1v13.8l-5 2.2-6.4-2.2-5 2.2V6.2Z" stroke="#31A268" stroke-width="1.6" stroke-linejoin="round"/><path d="M8.8 4v13.8M15.2 6.1V20" stroke="#31A268" stroke-width="1.4"/><path d="M12 8.2c-2 0-3.4 1.4-3.4 3.3 0 2.8 3.4 5.9 3.4 5.9s3.4-3.1 3.4-5.9c0-1.9-1.4-3.3-3.4-3.3Z" fill="#31A268" opacity=".16" stroke="#31A268" stroke-width="1.6"/><circle cx="12" cy="11.5" r="1.3" fill="#31A268"/></svg></span></span></div><div class="sensorcontent"><div class="label">GPS status</div><div class="value" id="homeGps">Geen satelliet gevonden</div><div class="sub" id="homeSats">0 satellieten</div></div></article><article class="sensor compact"><div class="sensoricon"><span class="iconwrap"><span class="symbol">◷</span></span></div><div class="sensorcontent"><div class="label">Tijd status</div><div class="value" id="homeTimeStatus">Gesynchroniseerd</div><div class="sub" id="homeTime">--:--:--</div></div></article></div><button class="sd" onclick="navigate('data')"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="#253044" stroke-width="1.8" stroke-linejoin="round" fill="none"/><path d="M14.7 3.8v4.7h4.5" stroke="#253044" stroke-width="1.8" stroke-linejoin="round"/><path d="M9.2 8.1h1.2M11.6 8.1h1.2M14 8.1h1.2" stroke="#253044" stroke-width="1.6" stroke-linecap="round"/><path d="M9.3 11.8h7.5v5.3H9.3z" fill="#253044" opacity=".14" stroke="#253044" stroke-width="1.5"/></svg></span></span></div><div class="sensorcontent"><div class="label">SD status</div><div class="value" id="homeSdStatus">Gereed</div><div class="sub" id="homeSdFree">-- vrij</div></div><span class="arrow">›</span></button></div></section>
<section id="measure" class="page"><div class="sheet"><div style="display:flex;justify-content:space-between;align-items:center;margin-bottom:9px"><button style="background:none;color:var(--navy);font-size:23px" aria-label="Terug naar dashboard" onclick="navigate('home')">‹</button><strong>Meten</strong><span style="width:38px" aria-hidden="true"></span></div><div class="heading"><div><h1 id="headline">Klaar voor nieuwe meetsessie</h1><p>Nieuwe meetsessie</p></div><span class="pill" id="badge">Stand-by</span></div><div class="clock" aria-label="Meetsessiestatistieken"><div class="metric"><span class="metric-label">Verstreken tijd</span><strong id="elapsed">00:00:00</strong></div><div class="metric"><span class="metric-label">Aantal metingen</span><strong id="count">0</strong></div></div><div class="settingrow"><div>⏱ <b>Meetinterval</b><small id="intervalcaption">Elke 0,1 seconde</small></div><button onclick="changeInterval()">Wijzigen</button></div><div id="activecontrols" class="measureactions hidden"><button class="continue" id="continuebtn" onclick="resumeOrNotice()">▶ Doorgaan</button><button class="pause" id="pausebtn" onclick="togglePause()">Ⅱ Pauzeren</button></div><button id="stopbtn" class="stop hidden" onclick="openStop()">■ &nbsp; Stop sessie</button><button id="startbtn" class="startbtn" onclick="start()"><span aria-hidden="true" style="display:inline-flex;vertical-align:middle;margin-right:7px"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span>START MET METEN</button><div class="measuregrid"><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M9 8.5a3 3 0 0 1 6 0v4a3 3 0 0 1-6 0v-4Z" stroke="#F2A51A" stroke-width="1.8"/><path d="M6.5 12.5a5.5 5.5 0 0 0 11 0M12 18v3M9.5 21h5" stroke="#F2A51A" stroke-width="1.8" stroke-linecap="round"/></svg></span></span></div><div class="tilecontent"><div class="label">Geluidssensor</div><div class="value" id="measureSoundRaw">Controleren...</div><div class="sub">MAX4466 · meetstatus</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3.8 6.2 8.8 4l6.4 2.1 5-2.1v13.8l-5 2.2-6.4-2.2-5 2.2V6.2Z" stroke="#31A268" stroke-width="1.6" stroke-linejoin="round"/><path d="M8.8 4v13.8M15.2 6.1V20" stroke="#31A268" stroke-width="1.4"/><path d="M12 8.2c-2 0-3.4 1.4-3.4 3.3 0 2.8 3.4 5.9 3.4 5.9s3.4-3.1 3.4-5.9c0-1.9-1.4-3.3-3.4-3.3Z" fill="#31A268" opacity=".16" stroke="#31A268" stroke-width="1.6"/><circle cx="12" cy="11.5" r="1.3" fill="#31A268"/></svg></span></span></div><div class="tilecontent"><div class="label">GPS status</div><div class="value" id="measureGps">Geen satelliet gevonden</div><div class="sub" id="measureSats">0 satellieten</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="#253044" stroke-width="1.8" stroke-linejoin="round" fill="none"/><path d="M14.7 3.8v4.7h4.5" stroke="#253044" stroke-width="1.8" stroke-linejoin="round"/><path d="M9.2 8.1h1.2M11.6 8.1h1.2M14 8.1h1.2" stroke="#253044" stroke-width="1.6" stroke-linecap="round"/><path d="M9.3 11.8h7.5v5.3H9.3z" fill="#253044" opacity=".14" stroke="#253044" stroke-width="1.5"/></svg></span></span></div><div class="tilecontent"><div class="label">SD kaart <span style="color:var(--green)">●</span></div><div class="value" id="sdwrite">Gereed</div><div class="sub" id="measureSdFree">-- vrij</div></div></div></div><div class="location"><div class="map" aria-label="Huidige GPS-locatie"></div><div class="locationaside"><b>Huidige locatie</b><p id="measureCoords">Geen satelliet gevonden</p><small id="measureAccuracy">Wachten op GPS-satelliet</small></div></div><p class="meta">DataLogger · live verbonden met Arduino UNO R4 WiFi.</p></div></section>
<section id="data" class="page"><div class="datawrap"><div class="datatop"><div><h1>Overzicht</h1></div><button class="periodpill" type="button" onclick="cyclePeriod()" id="periodButton">Laatste 30 dagen ˅</button></div><div class="overviewgrid"><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/><path d="M14.7 3.8v4.7h4.5" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/></svg></span></div><div class="overviewvalue" id="statSessions">12</div><div class="overviewlabel">Sessies</div></div><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M4 18h16M7 18V9m5 9V5m5 13v-7" stroke="currentColor" stroke-width="2" stroke-linecap="round"/></svg></span></div><div class="overviewvalue" id="statMeasurements">3.482</div><div class="overviewlabel">Metingen</div></div><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M6.5 6.5A2.5 2.5 0 0 1 9 4h6a2.5 2.5 0 0 1 2.5 2.5v11A2.5 2.5 0 0 1 15 20H9a2.5 2.5 0 0 1-2.5-2.5v-11Z" stroke="currentColor" stroke-width="1.8"/><path d="M9.5 7.5h5M9.5 10.5h5M9.5 13.5h5" stroke="currentColor" stroke-width="1.6" stroke-linecap="round"/></svg></span></div><div class="overviewvalue" id="statSize">248 MB</div><div class="overviewlabel">Totale grootte</div></div></div><h2 class="sectionhead">Meetbestanden</h2><div class="filetoolbar"><label class="searchbox" aria-label="Zoek in sessies"><span aria-hidden="true">⌕</span><input id="searchSessions" type="text" placeholder="Zoek in sessies..." oninput="renderFiles()"></label><button class="filterbtn" id="filterButton" type="button" onclick="toggleFilters()"><span aria-hidden="true"><svg width="18" height="18" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M4 6h16M7 12h10M10 18h4" stroke="currentColor" stroke-width="2" stroke-linecap="round"/></svg></span>Filteren</button></div><div class="filterpanel" id="filterPanel" hidden><span class="filterlabel">Sorteer op</span><div class="filteroptions"><button class="filteroption active" data-sort="newest" onclick="setDataSort('newest')">Nieuwste</button><button class="filteroption" data-sort="oldest" onclick="setDataSort('oldest')">Oudste</button><button class="filteroption" data-sort="largest" onclick="setDataSort('largest')">Grootste</button></div></div><div id="sessionList" class="sessionlist"></div></div></section>
<section id="charts" class="page"><div class="chartwrap"><h1>Grafieken</h1><p class="chartintro">Visualiseer de gegevens uit je opgeslagen meetsessies.</p><div class="chartpanel"><label class="chartlabel" for="chartSession">Meetsessie</label><select id="chartSession" class="chartselect" onchange="renderChart()"><option value="">Selecteer een meetsessie</option></select><div style="height:12px"></div><span class="chartlabel">Meetwaarde</span><div class="metricbuttons"><button id="metricSound" class="active" onclick="setChartMetric('sound')">Geluid</button></div></div><div class="chartpanel"><div class="charthead"><div><h2 id="chartTitle">Meetverloop</h2><small id="chartSubtitle" style="color:var(--muted)">Kies een meetsessie</small></div><div class="chartvalue"><strong id="chartLatest">--</strong><small id="chartUnit"></small></div></div><div id="chartCanvas" class="chart-empty">Stop eerst een meetsessie. Daarna kun je de opgeslagen data hier plotten.</div><div id="chartStats" class="chartstats" hidden><div class="chartstat"><small>Minimum</small><strong id="chartMin">--</strong></div><div class="chartstat"><small>Gemiddeld</small><strong id="chartAvg">--</strong></div><div class="chartstat"><small>Maximum</small><strong id="chartMax">--</strong></div></div><p class="chartnote">Grafieken worden rechtstreeks opgebouwd uit de CSV-bestanden op de SD-kaart.</p></div></div></section>
<section id="settings" class="page"><div class="settingswrap"><h1>Instellingen</h1>
<div class="settingssection"><h2>Apparaat</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('about')"><span class="settingicon">ⓘ</span><span class="settingcopy"><span class="settingtitle">Over je DataLogger</span><span class="settingdesc">Hardware, sensoren en firmware</span></span><span class="settingright"><span class="chevron">›</span></span></button>
<button class="settingitem" onclick="openModal('system')"><span class="settingicon">◉</span><span class="settingcopy"><span class="settingtitle">Systeemstatus</span><span class="settingdesc">Controleer sensoren en opslag</span></span><span class="settingright"><span class="statusok">Alles gereed</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Tijd &amp; locatie</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('timesync')"><span class="settingicon">◷</span><span class="settingcopy"><span class="settingtitle">Tijdsynchronisatie</span><span class="settingdesc">Voor tijdsafhankelijke metingen</span></span><span class="settingright"><span id="settingsTimeStatus">Gesynchroniseerd</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Metingen</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('interval')"><span class="settingicon">⏱</span><span class="settingcopy"><span class="settingtitle">Standaard meetinterval</span><span class="settingdesc">Tijd tussen twee meetpunten</span></span><span class="settingright"><span id="settingsInterval">0,1 s</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Data &amp; opslag</h2><div class="settingscard">
<button class="settingitem" onclick="navigate('data')"><span class="settingicon">▣</span><span class="settingcopy"><span class="settingtitle">SD-kaart</span><span class="settingdesc">Opslag en opgeslagen meetsessies</span></span><span class="settingright"><span>31,8 GB vrij</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Weergave</h2><div class="settingscard"><div class="themebuttons"><div class="themeswitch" id="themeSwitch" data-active="light" role="tablist" aria-label="Thema kiezen"><button id="themeLight" type="button" aria-pressed="false" onclick="theme('light')"><span class="themeglyph">☀</span><span>Licht</span></button><button id="themeDark" type="button" aria-pressed="false" onclick="theme('dark')"><span class="themeglyph">☾</span><span>Donker</span></button></div></div></div></div>
<div class="settingssection"><h2>Help</h2><div class="settingscard">
<button class="settingitem" onclick="openManualPage()"><span class="settingicon">?</span><span class="settingcopy"><span class="settingtitle">Handleiding Toolkit 1</span><span class="settingdesc">Aansluiten, meten, grafieken en problemen oplossen</span></span><span class="settingright"><span class="chevron">›</span></span></button>
</div><button class="walkthroughbtn" onclick="openModal('guide')">▶ &nbsp; Speel Walkthrough af</button></div>
</div></section>
<nav class="nav" aria-label="Hoofdnavigatie"><button class="selected" data-page="home" aria-label="Home" onclick="navigate('home')"><span class="navIconWrap"><svg class="navSvgIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><path d="M4 10.5 12 4l8 6.5V20H14v-5h-4v5H4v-9.5Z" stroke="currentColor" stroke-width="1.9" stroke-linejoin="round"/></svg></span></button><button data-page="measure" aria-label="Meten" onclick="navigate('measure')"><span aria-hidden="true"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span></button><button data-page="data" aria-label="Data" onclick="navigate('data')"><span class="navIconWrap"><svg class="navSvgIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><rect x="5" y="4" width="14" height="16" rx="2.3" stroke="currentColor" stroke-width="1.8"/><path d="M8 8h8M8 12h8M8 16h8" stroke="currentColor" stroke-width="1.7" stroke-linecap="round"/></svg></span></button><button data-page="charts" aria-label="Grafieken" onclick="navigate('charts')"><span class="chartNavIcon" aria-hidden="true"><i></i><i></i><i></i></span></button></nav></div>

<div class="manualviewer" id="manualViewer" aria-hidden="true"><div class="manualviewerbar"><strong>Toolkit 1 handleiding</strong><div class="manualvieweractions"><button class="manualviewerpdf" onclick="downloadManualPdf()">PDF</button><button class="manualviewerclose" onclick="closeManualPage()">Sluiten</button></div></div><iframe id="manualFrame" title="Toolkit 1 handleiding" loading="lazy"></iframe></div>
<div class="connectionlost" id="connectionLost" role="dialog" aria-modal="true" aria-labelledby="connectionLostTitle">
  <div class="connectionlost-inner">
    <div class="connectionlost-brand">Data<span>Logger</span></div>
    <div class="connectionlost-icon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M5 9.5a10.5 10.5 0 0 1 14 0M8.2 12.8a5.8 5.8 0 0 1 7.6 0M11 16a1.5 1.5 0 0 1 2 0" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/><path d="M4 4l16 16" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/></svg></div>
    <h1 id="connectionLostTitle">Je bent niet verbonden met het wifi-signaal van de Arduino-DataLogger.</h1>
    <p>Check de volgende onderdelen om weer connectie te maken.</p>
    <div class="connectionchecklist">
      <div class="connectioncheck"><div class="connectioncheck-num">1</div><div><b>Controleer de stroomvoorziening</b><small>Controleer of de Arduino-DataLogger aan staat en voeding krijgt via USB, powerbank of een geschikte externe voeding.</small></div></div>
      <div class="connectioncheck"><div class="connectioncheck-num">2</div><div><b>Maak opnieuw verbinding met het wifi-signaal</b><small>Open de wifi-instellingen van je telefoon en verbind opnieuw met het netwerk van de DataLogger.</small></div></div>
      <div class="connectioncheck"><div class="connectioncheck-num">3</div><div><b>Herlaad daarna de website</b><small>Zodra je telefoon weer verbonden is met de DataLogger kun je deze pagina opnieuw laden.</small></div></div>
    </div>
    <div class="connectionwifi">Wifi-netwerk: <code>Arduino-Logger</code><br>Wachtwoord: <code>Logger2026!</code></div>
    <div class="connectionactions"><button class="connectionretry" onclick="retryArduinoConnection()">Opnieuw proberen</button><button class="connectionreload" onclick="location.reload()">Website herladen</button></div>
    <div class="connectionstate" id="connectionState">Wachten op verbinding met de Arduino-DataLogger…</div>
  </div>
</div>
<div class="modaloverlay" id="modal"><div class="modal"><header><h2 id="modaltitle">Instellingen</h2><button class="close" aria-label="Sluiten" onclick="closeModal()">✕</button></header><div id="modalbody"></div></div></div><div id="toast" class="toast" role="status"></div>
<script>
let mode='idle',seconds=0,count=0,interval=0.1,toastTimer,guideStep=0;
let dataSort='newest',dataPeriod=30,chartMetric='sound',sessions=[],statusData={},sessionCsvCache=new Map();
const $=x=>document.getElementById(x);
let connectionFailures=0,connectionOverlayVisible=false;
const OFFLINE_HELP={title:'Je bent niet verbonden met het wifi-signaal van de Arduino-DataLogger.',steps:['Controleer of de Arduino-DataLogger stroom heeft.','Verbind je telefoon met wifi-netwerk Arduino-Logger.','Herlaad de website nadat de wifi-verbinding hersteld is.'],ssid:'Arduino-Logger'};
try{localStorage.setItem('datalogger-offline-help',JSON.stringify(OFFLINE_HELP));localStorage.setItem('datalogger-last-app-url',location.href)}catch(e){}
function showConnectionLost(){connectionOverlayVisible=true;const el=$('connectionLost');if(el)el.classList.add('show');const st=$('connectionState');if(st)st.textContent='Geen verbinding met de Arduino-DataLogger.'}
function hideConnectionLost(){connectionOverlayVisible=false;const el=$('connectionLost');if(el)el.classList.remove('show');const st=$('connectionState');if(st)st.textContent='Verbonden.'}
function noteConnectionSuccess(){connectionFailures=0;if(connectionOverlayVisible)hideConnectionLost()}
function noteConnectionFailure(){connectionFailures++;if(connectionFailures>=2)showConnectionLost()}
async function retryArduinoConnection(){const st=$('connectionState');if(st)st.textContent='Verbinding controleren…';try{const r=await fetch('/api/status?reconnect='+Date.now(),{cache:'no-store'});if(!r.ok)throw new Error('HTTP '+r.status);const s=await r.json();noteConnectionSuccess();updateUiFromStatus(s);if(st)st.textContent='Verbonden.'}catch(e){showConnectionLost();if(st)st.textContent='Nog geen verbinding. Controleer stroom en wifi.'}}
const esc=s=>String(s??'').replace(/[&<>"']/g,c=>({'&':'&amp;','<':'&lt;','>':'&gt;','"':'&quot;',"'":'&#39;'}[c]));
async function api(url){try{const r=await fetch(url,{cache:'no-store'});if(!r.ok)throw new Error(await r.text()||('HTTP '+r.status));noteConnectionSuccess();return r}catch(e){noteConnectionFailure();throw e}}
async function apiJson(url){return (await api(url)).json()}
function notify(t){$('toast').textContent=t;$('toast').classList.add('show');clearTimeout(toastTimer);toastTimer=setTimeout(()=>$('toast').classList.remove('show'),2500)}
function navigate(id){document.querySelectorAll('.page').forEach(p=>p.classList.toggle('current',p.id===id));document.querySelectorAll('.nav button').forEach(b=>{b.classList.toggle('selected',b.dataset.page===id);b.setAttribute('aria-current',b.dataset.page===id?'page':'false')});if(id==='data')loadSessions();if(id==='charts'){loadSessions().then(()=>{syncChartSessions();renderChart()})}scrollTo(0,0)}
function fmtClock(total){total=Math.max(0,Math.floor(Number(total)||0));let h=String(Math.floor(total/3600)).padStart(2,'0'),m=String(Math.floor(total%3600/60)).padStart(2,'0'),s=String(total%60).padStart(2,'0');return h+':'+m+':'+s}
function fmtSizeBytes(bytes){bytes=Math.max(0,Number(bytes)||0);if(bytes>=1073741824)return (bytes/1073741824).toFixed(1).replace('.',',')+' GB';if(bytes>=1048576)return (bytes/1048576).toFixed(1).replace('.',',')+' MB';if(bytes>=1024)return Math.max(1,Math.round(bytes/1024))+' KB';return bytes+' B'}
function fmtFreeMB(mb){mb=Number(mb);if(!Number.isFinite(mb)||mb<0)return 'SD gereed';if(mb>=1024)return (mb/1024).toFixed(1).replace('.',',')+' GB vrij';return Math.round(mb)+' MB vrij'}
function dateNl(iso){if(!iso)return 'Onbekende datum';const m=String(iso).match(/^(\d{4})-(\d{2})-(\d{2})/);if(!m)return iso;const months=['jan','feb','mrt','apr','mei','jun','jul','aug','sep','okt','nov','dec'];return Number(m[3])+' '+months[Number(m[2])-1]+' '+m[1]}
function updateUiFromStatus(s){statusData=s;mode=(s.state||'idle').toLowerCase();seconds=Number(s.elapsed)||0;count=Number(s.count)||0;interval=(Number(s.intervalMs)||100)/1000;
  $('elapsed').textContent=fmtClock(seconds);$('count').textContent=count.toLocaleString('nl-NL');
  $('headline').textContent=mode==='running'?'Geluidsmeting actief':mode==='paused'?'Geluidsmeting gepauzeerd':'Klaar voor geluidsmeting';
  $('badge').textContent=mode==='running'?'Actief':mode==='paused'?'Gepauzeerd':'Stand-by';$('badge').style.background=mode==='running'?'#d8f5e3':mode==='paused'?'#fff0d3':'#e9edf3';
  $('activecontrols').classList.toggle('hidden',mode==='idle');$('stopbtn').classList.toggle('hidden',mode==='idle');$('startbtn').classList.toggle('hidden',mode!=='idle');
  $('pausebtn').textContent=mode==='paused'?'Verder meten':'Ⅱ Pauzeren';$('continuebtn').textContent=mode==='paused'?'Verder meten':'Doorgaan';
  $('intervalcaption').textContent='Elke '+String(interval).replace('.',',')+' '+(interval<=1?'seconde':'seconden');const si=$('settingsInterval');if(si)si.textContent=String(interval).replace('.',',')+' s';
  const sensorTxt=s.sensorReady?'Actief':'Niet actief';
  if($('homeSound'))$('homeSound').textContent=sensorTxt;if($('measureSound'))$('measureSound').textContent=sensorTxt;if($('homeSoundRaw'))$('homeSoundRaw').textContent=sensorTxt;if($('measureSoundRaw'))$('measureSoundRaw').textContent=sensorTxt;
  const fix=!!s.positionValid,gpsTxt=fix?'Satelliet gevonden':'Geen satelliet gevonden',satTxt=(Number(s.satellites)||0)+' satellieten';if($('homeGps'))$('homeGps').textContent=gpsTxt;if($('measureGps'))$('measureGps').textContent=gpsTxt;if($('homeSats'))$('homeSats').textContent=satTxt;if($('measureSats'))$('measureSats').textContent=satTxt;
  if($('homeTime'))$('homeTime').textContent=s.rtcTime||'--:--:--';if($('homeTimeStatus'))$('homeTimeStatus').textContent=s.rtcSynced?'Gesynchroniseerd':'Synchroniseren';if($('settingsTimeStatus'))$('settingsTimeStatus').textContent=s.rtcSynced?'Gesynchroniseerd':'Synchroniseren';
  const sdOk=!!s.sdReady,free=fmtFreeMB(s.sdFreeMB);if($('homeSdStatus'))$('homeSdStatus').textContent=sdOk?'Gereed':'Fout';if($('homeSdFree'))$('homeSdFree').textContent=free;if($('measureSdFree'))$('measureSdFree').textContent=free;if($('sdwrite'))$('sdwrite').textContent=mode==='running'?'Schrijven...':sdOk?'Gereed':'Fout';
  if($('systemSensors'))$('systemSensors').textContent=(s.sensorReady&&s.sdReady&&s.rtcReady)?'MAX4466 actief':'Controleer sensorstatus';
  if($('measureCoords'))$('measureCoords').innerHTML=fix?(Number(s.latitude).toFixed(6)+'° N<br>'+Number(s.longitude).toFixed(6)+'° E'):'Geen satelliet gevonden';if($('measureAccuracy'))$('measureAccuracy').innerHTML=fix?('Satelliet gevonden · bron: '+esc(s.locationSource||'GPS')):'Wachten op GPS-satelliet';
}
async function pollStatus(){try{updateUiFromStatus(await apiJson('/api/status'))}catch(e){if($('systemSensors'))$('systemSensors').textContent='Verbinding verbroken'}}
async function start(){try{await api('/api/start');await pollStatus();notify('Nieuwe meetsessie gestart')}catch(e){notify('Starten mislukt: '+e.message)}}
async function togglePause(){try{await api(mode==='paused'?'/api/resume':'/api/pause');await pollStatus();notify(mode==='paused'?'Meting gepauzeerd':'Status bijgewerkt')}catch(e){notify('Actie mislukt: '+e.message)}}
function resumeOrNotice(){if(mode==='paused')togglePause();else notify('Je bent al aan het meten')}
function openStop(){openModal('stop')}
async function finish(){try{await api('/api/stop');closeModal();await pollStatus();await loadSessions();notify('Meetsessie opgeslagen op SD-kaart')}catch(e){notify('Stoppen mislukt: '+e.message)}}
function getDisplaySessions(){let list=[...sessions];const q=($('searchSessions')?.value||'').trim().toLowerCase();if(q)list=list.filter(f=>('datalogger_meetsessie_'+f.id).includes(q)||String(f.id).includes(q));if(dataPeriod>0){const cutoff=Date.now()-dataPeriod*86400000;list=list.filter(f=>{if(!f.start)return true;const t=Date.parse(f.start.replace(' ','T'));return !Number.isFinite(t)||t>=cutoff})}list.sort((a,b)=>dataSort==='oldest'?a.id-b.id:dataSort==='largest'?b.size-a.size:b.id-a.id);return list}
async function loadSessions(){try{const j=await apiJson('/api/sessions');sessions=Array.isArray(j.sessions)?j.sessions:[];renderFiles();syncChartSessions();return sessions}catch(e){sessions=[];renderFiles();return []}}
function renderFiles(){const list=getDisplaySessions(),root=$('sessionList');if(!root)return;root.replaceChildren();if(!list.length){root.innerHTML='<div class="emptyhint">Geen sessies gevonden.</div>'}else list.forEach(f=>{const row=document.createElement('div');row.className='sessionrow';const icon=document.createElement('div');icon.className='fileicon';icon.innerHTML='<svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/><path d="M14.7 3.8v4.7h4.5" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/></svg>';const info=document.createElement('div');info.style.minWidth='0';info.innerHTML='<div class="sessiontitle">DataLogger_meetsessie_'+f.id+'</div><div class="sessionmeta">'+esc(dateNl(f.start))+' &nbsp; '+esc(fmtClock(f.duration))+'</div><div class="sessionsub">'+Number(f.count||0).toLocaleString('nl-NL')+' metingen &nbsp; · &nbsp; '+esc(fmtSizeBytes(f.size||0))+'</div>';const btn=document.createElement('button');btn.className='sessionmenubtn';btn.type='button';btn.setAttribute('aria-label','Acties voor meetsessie '+f.id);btn.innerHTML='⋮';btn.onclick=()=>openSessionActions(f);row.append(icon,info,btn);root.appendChild(row)});
  const all=sessions;$('statSessions').textContent=all.length;$('statMeasurements').textContent=all.reduce((a,b)=>a+(Number(b.count)||0),0).toLocaleString('nl-NL');$('statSize').textContent=fmtSizeBytes(all.reduce((a,b)=>a+(Number(b.size)||0),0));}
function sessionByNumber(n){return sessions.find(x=>Number(x.id)===Number(n))}
function toggleFilters(){const p=$('filterPanel'),b=$('filterButton');p.hidden=!p.hidden;b.classList.toggle('active',!p.hidden)}
function setDataSort(s){dataSort=s;document.querySelectorAll('.filteroption').forEach(b=>b.classList.toggle('active',b.dataset.sort===s));renderFiles()}
function cyclePeriod(){const opts=[30,90,365,0],labels={30:'Laatste 30 dagen ˅',90:'Laatste 90 dagen ˅',365:'Laatste jaar ˅',0:'Alle data ˅'};dataPeriod=opts[(opts.indexOf(dataPeriod)+1)%opts.length];$('periodButton').textContent=labels[dataPeriod];renderFiles()}
function openSessionActions(f){$('modaltitle').textContent='Meetsessie '+f.id;$('modalbody').innerHTML='<div class="sessionactionsheet"><button class="sessionaction" onclick="downloadCSVByNumber('+f.id+')"><span class="saicon">⇩</span><span>Downloaden<small>Download als CSV-bestand</small></span></button><button class="sessionaction" onclick="shareSession('+f.id+')"><span class="saicon">↗</span><span>Delen<small>Deel het CSV-bestand</small></span></button><button class="sessionaction" onclick="inspectSession('+f.id+')"><span class="saicon">⌕</span><span>Data inkijken<small>Bekijk alle gemeten waarden</small></span></button><button class="sessionaction danger" onclick="confirmDeleteSession('+f.id+')"><span class="saicon">⌫</span><span>Verwijderen<small>Verwijder deze meetsessie permanent</small></span></button></div>';$('modal').classList.add('open')}
function downloadCSVByNumber(n){location.href='/api/download?id='+encodeURIComponent(n)}
async function getSessionCsv(n,refresh=false){if(!refresh&&sessionCsvCache.has(n))return sessionCsvCache.get(n);const t=await (await api('/api/download?id='+encodeURIComponent(n))).text();sessionCsvCache.set(n,t);return t}
async function shareSession(n){const f=sessionByNumber(n);if(!f)return;try{const text=await getSessionCsv(n,true),file=new File([text],'DataLogger_meetsessie_'+n+'.csv',{type:'text/csv'});if(navigator.canShare&&navigator.canShare({files:[file]})&&navigator.share){await navigator.share({title:'DataLogger meetsessie '+n,files:[file]})}else if(navigator.share){await navigator.share({title:'DataLogger meetsessie '+n,text:'DataLogger_meetsessie_'+n+'.csv'})}else{downloadCSVByNumber(n);notify('Delen niet ondersteund; CSV wordt gedownload')}}catch(e){if(e.name!=='AbortError')notify('Delen mislukt')}}
function parseCSV(text){const lines=text.replace(/\r/g,'').split('\n').filter(Boolean);if(!lines.length)return {headers:[],rows:[]};const headers=lines[0].split(',').map(x=>x.trim());return {headers,rows:lines.slice(1).map(line=>{const a=line.split(',');const o={};headers.forEach((h,i)=>o[h]=a[i]??'');return o})}}
async function inspectSession(n){const f=sessionByNumber(n);if(!f)return;$('modaltitle').textContent='DataLogger_meetsessie_'+n;$('modalbody').innerHTML='<div class="datatableempty">Meetdata laden...</div>';$('modal').classList.add('open');try{const p=parseCSV(await getSessionCsv(n));const rows=p.rows;const pick=(r,...names)=>{for(const k of names)if(k in r)return r[k];return ''};let trs=rows.map((r,i)=>'<tr><td class="num">'+esc(pick(r,'measurement_id')||i+1)+'</td><td>'+esc((pick(r,'rtc_datetime_local')||'').split(' ')[1]||pick(r,'rtc_datetime_local'))+'</td><td class="num">'+esc(pick(r,'sound_p2p_mV'))+'</td><td class="num">'+esc(pick(r,'sound_p2p_adc'))+'</td><td class="num">'+esc(pick(r,'latitude'))+'</td><td class="num">'+esc(pick(r,'longitude'))+'</td><td class="num">'+esc(pick(r,'satellites'))+'</td></tr>').join('');if(!trs)trs='<tr><td colspan="7" class="datatableempty">Deze sessie bevat nog geen meetpunten.</td></tr>';$('modalbody').innerHTML='<div class="datatablewrap"><table class="datatable"><thead><tr><th>#</th><th>Tijd</th><th class="num">Geluid mV p-p</th><th class="num">ADC p-p</th><th class="num">Latitude</th><th class="num">Longitude</th><th class="num">Sat.</th></tr></thead><tbody>'+trs+'</tbody></table></div>'}catch(e){$('modalbody').innerHTML='<div class="datatableempty">Data laden mislukt: '+esc(e.message)+'</div>'}}
function confirmDeleteSession(n){const f=sessionByNumber(n);if(!f)return;$('modaltitle').textContent='Meetsessie verwijderen?';$('modalbody').innerHTML='<p style="font-size:13px;color:var(--muted);line-height:1.5">DataLogger_meetsessie_'+n+' wordt permanent van de SD-kaart verwijderd. Dit kan niet ongedaan worden gemaakt.</p><div class="measureactions"><button class="continue" onclick="openSessionActions(sessionByNumber('+n+'))">Annuleren</button><button class="stop" onclick="deleteSession('+n+')">Verwijderen</button></div>'}
async function deleteSession(n){try{await api('/api/delete?id='+encodeURIComponent(n));sessionCsvCache.delete(n);closeModal();await loadSessions();notify('Meetsessie verwijderd')}catch(e){notify('Verwijderen mislukt: '+e.message)}}
function changeInterval(){openModal('interval')}
function closeModal(){$('modal').classList.remove('open')}
function openManualPage(){const v=$('manualViewer'),f=$('manualFrame');if(f&&!f.src)f.src='/handleiding';if(v){v.classList.add('open');v.setAttribute('aria-hidden','false');document.body.style.overflow='hidden'}}
function closeManualPage(){const v=$('manualViewer');if(v){v.classList.remove('open');v.setAttribute('aria-hidden','true');document.body.style.overflow=''}}
function downloadManualPdf(){window.open('/handleiding?print=1','_blank')}

const GUIDE_STEPS=[
{title:'Welkom bij DataLogger',eyebrow:'Stap 1 van 5',body:`<div class="guidehero"><span class="guideeyebrow">◉ Klaar om te starten</span><h3>We helpen je in een paar stappen op weg.</h3><p>Deze walkthrough laat zien hoe je de tijd synchroniseert, navigeert in de app en een meetsessie correct uitvoert.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">⌂</div><div><b>Home</b><small>Bekijk live sensordata en start snel een sessie.</small></div></div><div class="guideitem"><div class="guideitemicon">▶</div><div><b>Meten</b><small>Voer je meetsessie uit, pauzeer of stop en sla op.</small></div></div><div class="guideitem"><div class="guideitemicon">▤</div><div><b>Data & grafieken</b><small>Download CSV-bestanden en bekijk trends van opgeslagen sessies.</small></div></div></div>`},
{title:'Synchroniseer de tijd',eyebrow:'Stap 2 van 5',body:`<div class="guidehero"><span class="guideeyebrow">◷ Tijd is belangrijk</span><h3>Zorg eerst voor correcte tijdsafhankelijke metingen.</h3><p>Synchroniseer de tijd van je DataLogger met deze telefoon voordat je een nieuwe sessie start.</p></div><div class="guidecard"><h4>Waarom dit nodig is</h4><p>Alle metingen en CSV-bestanden krijgen een tijdstempel. Een correcte klok voorkomt verwarring tijdens analyse.</p></div><div class="guideinline"><button class="modalaction" onclick="syncTimeFromPhone()">Synchroniseer tijd</button></div>`},
{title:'Kies je weergave',eyebrow:'Stap 3 van 5',body:`<div class="guidehero"><span class="guideeyebrow">☀ / ☾ Weergave</span><h3>Kies het thema dat jij prettig vindt.</h3><p>Je keuze wordt onthouden op dit apparaat.</p></div><div class="guidethemeinline" id="guideThemeSwitch" data-active="__THEME_ACTIVE__"><button class="__LIGHT_ACTIVE__" onclick="guideThemeSwitch('light')">☀ Licht thema</button><button class="__DARK_ACTIVE__" onclick="guideThemeSwitch('dark')">☾ Donker thema</button></div><div class="guidecard"><h4>Goed om te weten</h4><p>Het thema verandert alleen de app-weergave en heeft geen invloed op je metingen of opgeslagen data.</p></div>`},
{title:'Zo voer je een meetsessie uit',eyebrow:'Stap 4 van 5',body:`<div class="guidehero"><span class="guideeyebrow">▶ Meten</span><h3>Meten werkt in drie eenvoudige acties.</h3><p>Open de Meet-pagina om een sessie te starten. Je ziet daar ook het interval, live sensorstatus en de GPS-locatie van de Air530Z.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">1</div><div><b>Start met meten</b><small>Begint een nieuwe sessie en zet de teller op nul.</small></div></div><div class="guideitem"><div class="guideitemicon">2</div><div><b>Pauzeren / verder meten</b><small>Pauzeer tijdelijk als je geen onnodige meetpunten wilt opslaan.</small></div></div><div class="guideitem"><div class="guideitemicon">3</div><div><b>Stop sessie</b><small>Slaat je sessie definitief op zodat deze beschikbaar wordt in Data en Grafieken.</small></div></div></div>`},
{title:'Je bent klaar',eyebrow:'Stap 5 van 5',body:`<div class="guidehero"><span class="guideeyebrow">✓ Klaar voor gebruik</span><h3>Je DataLogger is klaar om te meten.</h3><p>Ga nu naar Home voor een overzicht of open direct de Meet-pagina om een nieuwe sessie te starten.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">⤓</div><div><b>Data</b><small>Download, deel en inspecteer CSV-bestanden van opgeslagen sessies.</small></div></div><div class="guideitem"><div class="guideitemicon">▥</div><div><b>Grafieken</b><small>Visualiseer temperatuur en luchtvochtigheid per sessie.</small></div></div></div><div class="guidecallout">Je kunt deze walkthrough later opnieuw starten via Instellingen → Help.</div>`}
];
function renderGuide(){const step=GUIDE_STEPS[guideStep];$('modaltitle').textContent=step.title;let body=step.body;if(guideStep===2){const dark=document.documentElement.getAttribute('data-theme')==='dark';body=body.replace('__LIGHT_ACTIVE__',dark?'':'active').replace('__DARK_ACTIVE__',dark?'active':'').replace('__THEME_ACTIVE__',dark?'dark':'light')}$('modalbody').innerHTML=body+`<div class="guideprogress"><small>${step.eyebrow}</small><div class="guidedots">${GUIDE_STEPS.map((_,i)=>`<span class="guidedot ${i===guideStep?'active':''}"></span>`).join('')}</div></div><div class="guideactions"><button class="guidebtn secondary" ${guideStep===0?'disabled':''} onclick="guidePrev()">Terug</button><div class="guideactionstack">${guideStep<GUIDE_STEPS.length-1?'<button class="guidebtn primary" onclick="guideNext()">Volgende</button>':'<button class="guidebtn primary" onclick="closeModal();navigate(\'home\')">Open dashboard</button>'}</div></div>`}
function guideNext(){if(guideStep<GUIDE_STEPS.length-1){guideStep++;renderGuide()}}
function guidePrev(){if(guideStep>0){guideStep--;renderGuide()}}
function guideThemeSwitch(name){const sw=$('guideThemeSwitch');if(sw){const dark=name==='dark';sw.dataset.active=dark?'dark':'light';const b=sw.querySelectorAll('button');b[0]?.classList.toggle('active',!dark);b[1]?.classList.toggle('active',dark)}theme(name)}
async function syncTimeFromPhone(){const d=new Date(),q=`/api/time?y=${d.getFullYear()}&mo=${d.getMonth()+1}&d=${d.getDate()}&h=${d.getHours()}&mi=${d.getMinutes()}&s=${d.getSeconds()}`;try{await api(q);await pollStatus();const m=$('modalTimeState');if(m)m.textContent='Zojuist gesynchroniseerd';const p=$('phoneTimePreview');if(p)p.textContent=d.toLocaleTimeString('nl-NL');notify('Tijd gesynchroniseerd met telefoon')}catch(e){notify('Synchroniseren mislukt')}}
function theme(name){const c=name==='dark'?'dark':'light';document.documentElement.setAttribute('data-theme',c);try{localStorage.setItem('datalogger-theme',c)}catch(e){}$('themeLight')?.setAttribute('aria-pressed',String(c==='light'));$('themeDark')?.setAttribute('aria-pressed',String(c==='dark'));const sw=$('themeSwitch');if(sw)sw.dataset.active=c;$('browserThemeColor').setAttribute('content',c==='dark'?'#232323':'#343F58')}
function chooseInterval(n){window.pendingInterval=n;$('customSeconds').value='';$('intervalCustom').classList.remove('selected');$('intervalError').textContent='';document.querySelectorAll('.interval-choice').forEach(b=>b.setAttribute('aria-pressed',String(Number(b.querySelector('span').textContent)===n)));$('intervalHelp').textContent='Iedere '+String(n).replace('.',',')+' '+(n<=1?'seconde':'seconden')+' een geluidsmeetpunt.'}
function customIntervalChanged(){const input=$('customSeconds'),raw=input.value.trim().replace(',','.'),n=Number(raw),valid=/^\d+(?:\.\d{1,3})?$/.test(raw)&&n>=0.05&&n<=2147483&&Number.isInteger(Math.round(n*1000));document.querySelectorAll('.interval-choice').forEach(b=>b.setAttribute('aria-pressed','false'));$('intervalCustom').classList.toggle('selected',valid);$('intervalError').textContent=raw&&!valid?'Vul minimaal 0,05 seconde in, met maximaal drie decimalen.':'';window.pendingInterval=valid?n:null;$('intervalHelp').textContent=valid?'Iedere '+String(n).replace('.',',')+' '+(n<=1?'seconde':'seconden')+' een geluidsmeetpunt.':'Vul zelf je interval in, bijvoorbeeld 0,05, 0,1 of 0,25.'}
async function saveInterval(){const n=window.pendingInterval;if(!Number.isFinite(n)||n<0.05){$('intervalError').textContent='Kies minimaal 0,05 seconde.';return}try{await api('/api/interval?ms='+Math.round(n*1000));closeModal();await pollStatus();notify('Meetinterval gewijzigd naar '+String(n).replace('.',',')+' s')}catch(e){notify('Interval opslaan mislukt')}}

function openModal(which){const title=$('modaltitle'),body=$('modalbody');body.replaceChildren();if(which==='stop'){title.textContent='Meetsessie stoppen?';body.innerHTML='<p>Je sluit deze meetsessie definitief af en bewaart de gegevens. Pauzeren houdt dezelfde sessie open.</p><div class="measureactions"><button class="continue" onclick="closeModal()">Annuleren</button><button class="stop" onclick="finish()">Stop en bewaar</button></div>'}
else if(which==='interval'){title.textContent='Meetinterval';body.innerHTML='<p class="interval-intro">Kies hoe vaak je DataLogger een nieuw meetpunt opslaat.</p><div class="interval-choices" id="intervalChoices" role="group" aria-label="Meetinterval kiezen"></div><div class="interval-custom" id="intervalCustom"><label for="customSeconds">Zelf aantal seconden invullen<small>Ook decimalen mogelijk, bijvoorbeeld 0,1 of 0,25 seconde</small></label><input id="customSeconds" type="text" inputmode="decimal" autocomplete="off" placeholder="bijv. 0,05" oninput="customIntervalChanged()"></div><p class="interval-error" id="intervalError" role="alert"></p><div class="interval-help" id="intervalHelp"></div><button class="startbtn interval-save" onclick="saveInterval()">Interval opslaan</button>';window.pendingInterval=interval;[0.05,0.1,0.25,0.5,1,2,5].forEach(n=>{const b=document.createElement('button');b.className='interval-choice';b.type='button';b.setAttribute('aria-pressed',String(n===interval));b.innerHTML='<span>'+n+'</span><small>'+(n===1?'seconde':'seconden')+'</small>';b.onclick=()=>chooseInterval(n);$('intervalChoices').appendChild(b)});if(![0.05,0.1,0.25,0.5,1,2,5].includes(interval)){$('customSeconds').value=String(interval).replace('.',',');customIntervalChanged()}else chooseInterval(interval)}
else if(which==='system'){title.textContent='Systeemstatus';const s=statusData;body.innerHTML='<div class="modalinfo"><div class="modalinforow"><span>MAX4466 geluid</span><span>'+(s.sensorReady?'Actief':'Niet gevonden')+'</span></div><div class="modalinforow"><span>Air530Z GPS</span><span>'+(s.gpsSeen?'NMEA actief':'Geen data')+'</span></div><div class="modalinforow"><span>SD-kaart</span><span>'+(s.sdReady?'Gereed':'Fout')+'</span></div><div class="modalinforow"><span>DS1307 tijd</span><span>'+(s.rtcReady?'Actief':'Niet gevonden')+'</span></div><div class="modalinforow"><span>WiFi</span><span>Arduino-Logger-01</span></div></div>'}
else if(which==='timesync'){title.textContent='Synchroniseer de tijd';body.innerHTML='<p style="font-size:13px;color:var(--muted);line-height:1.5">Synchroniseer de tijd van je DataLogger met de actuele tijd van deze telefoon. Dit is belangrijk voor tijdsafhankelijke metingen.</p><div class="modalinfo"><div class="modalinforow"><span>Status</span><span id="modalTimeState">'+(statusData.rtcSynced?'Gesynchroniseerd':'Nog synchroniseren')+'</span></div><div class="modalinforow"><span>Telefoontijd</span><span id="phoneTimePreview">'+new Date().toLocaleTimeString('nl-NL')+'</span></div></div><button class="modalaction" onclick="syncTimeFromPhone()">Synchroniseer tijd</button>'}
else if(which==='about'){title.textContent='Over je DataLogger';body.innerHTML='<section><b>Arduino UNO R4 WiFi</b><p>Microcontroller en lokaal WiFi-netwerk.</p></section><section><b>Grove Air530Z</b><p>GPS-positie, snelheid en UTC-tijd via UART.</p></section><section><b>MAX4466 microfoonversterker</b><p>Analoge geluidsamplitude via A0. De waarde is piek-tot-piek en niet gekalibreerd in dB(A).</p></section><section><b>Keyes Logging Shield</b><p>SD-kaart en DS1307-klok met reservebatterij.</p></section>'}
else if(which==='guide'){guideStep=0;renderGuide()}$('modal').classList.add('open')}
function syncChartSessions(){const sel=$('chartSession');if(!sel)return;const prev=sel.value;sel.innerHTML='<option value="">Selecteer een meetsessie</option>';sessions.forEach(f=>{const o=document.createElement('option');o.value=String(f.id);o.textContent='Meetsessie '+f.id+' · '+Number(f.count||0).toLocaleString('nl-NL')+' meetpunten';sel.appendChild(o)});if(sessions.some(f=>String(f.id)===prev))sel.value=prev;else if(sessions.length)sel.value=String(sessions[0].id)}
function setChartMetric(metric){chartMetric='sound';renderChart()}
function fmtChartTime(sec){if(sec<60)return Math.round(sec)+' s';if(sec<3600)return Math.round(sec/60)+' min';return (sec/3600).toFixed(1).replace('.',',')+' u'}
async function renderChart(){
  const canvas=$('chartCanvas'),stats=$('chartStats'),select=$('chartSession');
  if(!canvas||!select)return;
  const id=Number(select.value);
  if(!id){
    canvas.className='chart-empty';
    canvas.innerHTML='Kies een opgeslagen meetsessie.';
    stats.hidden=true;
    return;
  }
  canvas.className='chart-empty';
  canvas.innerHTML='Meetdata laden...';
  try{
    const parsed=parseCSV(await getSessionCsv(id));
    const rows=parsed.rows.filter(r=>Number.isFinite(Number(r.sound_p2p_mV)));
    const vals=rows.map(r=>Number(r.sound_p2p_mV));
    if(!vals.length)throw new Error('Geen geldige geluidsdata');

    const session=sessionByNumber(id);
    let times=rows.map(r=>{
      const ms=Number(r.elapsed_ms);
      return Number.isFinite(ms)?ms/1000:NaN;
    });

    if(!times.every(Number.isFinite)){
      const duration=Number(session&&session.duration)||0;
      const step=duration>0&&vals.length>1?duration/(vals.length-1):Math.max(0.05,interval||0.1);
      times=vals.map((_,i)=>i*step);
    }

    const totalDuration=Math.max(0.05,times[times.length-1]||0);
    const visibleSeconds=20;
    const viewportWidth=Math.max(320,canvas.clientWidth||360);
    const yAxisWidth=48;
    const plotViewport=Math.max(240,viewportWidth-yAxisWidth-2);
    const pxPerSecond=plotViewport/visibleSeconds;

    const top=16,bottom=42,h=245;
    const plotLeft=0,right=18;
    const plotWidth=Math.max(plotViewport,totalDuration*pxPerSecond);
    const w=plotWidth+right;
    const ph=h-top-bottom;

    let min=Math.min(...vals),max=Math.max(...vals);
    if(max-min<1){min-=.5;max+=.5}
    const pad=(max-min)*.14;
    min-=pad;max+=pad;

    const x=t=>plotLeft+(t/Math.max(totalDuration,visibleSeconds))*plotWidth;
    const y=v=>top+(max-v)/(max-min)*ph;

    const pts=vals.map((v,i)=>x(times[i]).toFixed(1)+','+y(v).toFixed(1)).join(' ');
    const firstX=x(times[0]);
    const lastX=x(times[times.length-1]);
    const area=firstX+','+(top+ph)+' '+pts+' '+lastX+','+(top+ph);

    let yAxis='';
    for(let i=0;i<=4;i++){
      const yy=top+i*ph/4,val=max-i*(max-min)/4;
      yAxis+='<text class="chartaxis" text-anchor="end" x="42" y="'+(yy+3)+'">'+val.toFixed(0)+'</text>';
    }

    let grid='';
    for(let i=0;i<=4;i++){
      const yy=top+i*ph/4;
      grid+='<line class="chartgridline" x1="0" x2="'+plotWidth+'" y1="'+yy+'" y2="'+yy+'"/>';
    }

    const tickStep=5;
    const xAxisY=top+ph;
    grid+='<line class="chartgridline" x1="0" x2="'+plotWidth+'" y1="'+xAxisY+'" y2="'+xAxisY+'"/>';
    for(let t=0;t<=Math.ceil(totalDuration/tickStep)*tickStep;t+=tickStep){
      const xx=x(t);
      grid+='<line class="chartgridline" x1="'+xx+'" x2="'+xx+'" y1="'+xAxisY+'" y2="'+(xAxisY+5)+'"/>'+
            '<text class="chartaxis" text-anchor="middle" x="'+xx+'" y="'+(xAxisY+18)+'">'+t+' s</text>';
    }
    grid+='<text class="chartaxis" text-anchor="middle" x="'+(plotWidth/2)+'" y="'+(h-5)+'">Tijd</text>';

    const last=vals[vals.length-1];

    canvas.className='chartbox';
    canvas.innerHTML=
      '<div class="chartyaxis">'+
        '<svg viewBox="0 0 48 '+h+'" preserveAspectRatio="none">'+yAxis+'</svg>'+
      '</div>'+
      '<div class="chartscroll" id="chartScroll">'+
        '<svg width="'+w+'" height="'+h+'" viewBox="0 0 '+w+' '+h+'">'+
          grid+
          '<polygon class="chartarea" points="'+area+'"/>'+
          '<polyline class="chartline" points="'+pts+'"/>'+
          '<circle class="chartdot" cx="'+lastX+'" cy="'+y(last)+'" r="4"/>'+
        '</svg>'+
      '</div>';

    const scroller=$('chartScroll');
    if(scroller)scroller.scrollLeft=0;

    $('chartTitle').textContent='Geluidsamplitude';
    $('chartSubtitle').textContent='Meetsessie '+id+' · '+vals.length+' meetpunten · '+totalDuration.toFixed(1).replace('.',',')+' s';
    $('chartLatest').textContent=last.toFixed(0);
    $('chartUnit').textContent='mV p-p';

    const avg=vals.reduce((a,b)=>a+b,0)/vals.length;
    $('chartMin').textContent=Math.min(...vals).toFixed(0)+' mV p-p';
    $('chartAvg').textContent=avg.toFixed(0)+' mV p-p';
    $('chartMax').textContent=Math.max(...vals).toFixed(0)+' mV p-p';
    stats.hidden=false;
  }catch(e){
    canvas.className='chart-empty';
    canvas.innerHTML='Grafiek laden mislukt: '+esc(e.message);
    stats.hidden=true;
  }
}
try{theme(localStorage.getItem('datalogger-theme')||'light')}catch(e){theme('light')}
window.addEventListener('online',()=>setTimeout(retryArduinoConnection,250));
window.addEventListener('offline',()=>setTimeout(()=>{pollStatus()},250));
pollStatus();loadSessions();setInterval(pollStatus,1000);
</script></body></html>
)DATALOGGER";

// ---------- Helpers ----------
String sessionPath(uint32_t id){ char b[32]; snprintf(b,sizeof(b),"%s/S%04lu.CSV",LOG_DIR,(unsigned long)id); return String(b); }
String twoDigits(int v){ return (v<10?"0":"")+String(v); }
String formatDateTime(const DateTime &dt){ return String(dt.year())+"-"+twoDigits(dt.month())+"-"+twoDigits(dt.day())+" "+twoDigits(dt.hour())+":"+twoDigits(dt.minute())+":"+twoDigits(dt.second()); }
String formatTimeOnly(const DateTime &dt){ return twoDigits(dt.hour())+":"+twoDigits(dt.minute())+":"+twoDigits(dt.second()); }
uint32_t elapsedSessionMs(){ if(sessionState==STATE_RUNNING) return accumulatedRunMs + (uint32_t)(millis()-runStartedMs); return accumulatedRunMs; }
const char* stateName(){ return sessionState==STATE_RUNNING?"running":sessionState==STATE_PAUSED?"paused":"idle"; }
bool validArduinoFix(){ return gps.location.isValid() && gps.location.age()<5000 && gps.satellites.isValid() && gps.satellites.value()>0; }
bool validGpsUtc(){ return gps.date.isValid() && gps.time.isValid() && gps.date.age()<5000 && gps.time.age()<5000 && gps.date.year()>=2024 && gps.date.year()<=2100; }

bool selectedPosition(double &lat,double &lon,const char* &source){
  if(validArduinoFix()){
    lat=gps.location.lat();
    lon=gps.location.lng();
    source="Air530Z";
    return true;
  }
  source="Geen";
  lat=0;
  lon=0;
  return false;
}

void readGps(){ while(Serial1.available()){ char c=(char)Serial1.read(); gps.encode(c); gpsSeen=true; } }
void readSensors(){
  const uint32_t windowMs=50;
  uint32_t start=millis();
  uint16_t lo=4095, hi=0;
  uint32_t sum=0, n=0;
  while((uint32_t)(millis()-start)<windowMs){
    uint16_t v=(uint16_t)analogRead(SOUND_PIN);
    if(v<lo)lo=v;if(v>hi)hi=v;sum+=v;n++;
    readGps();
  }
  liveSoundAdc=(hi>=lo)?(hi-lo):0;
  liveSoundMv=(liveSoundAdc*5000.0f)/4095.0f;
  liveSoundBiasV=n?((sum/(float)n)*5.0f/4095.0f):NAN;
  sensorReady=!isnan(liveSoundBiasV) && liveSoundBiasV>0.4f && liveSoundBiasV<3.0f;
  lastSensorReadMs=millis();
}

uint32_t findNextSessionId(){
  uint32_t maxId=0;
  if(!sdReady)return 1;
  File dir=SD.open(LOG_DIR); if(!dir)return 1;
  for(File f=dir.openNextFile(); f; f=dir.openNextFile()){
    if(!f.isDirectory()){
      String n=String(f.name()); int p=n.lastIndexOf('/'); if(p>=0)n=n.substring(p+1);
      if(n.startsWith("S") && n.endsWith(".CSV")){ uint32_t id=(uint32_t)n.substring(1,n.length()-4).toInt(); if(id>maxId)maxId=id; }
    }
    f.close();
  }
  dir.close(); return maxId+1;
}

bool ensureLogDir(){ if(SD.exists(LOG_DIR))return true; return SD.mkdir(LOG_DIR); }

void writeCsvHeader(File &f){
  f.println("measurement_id,rtc_datetime_local,elapsed_ms,sound_p2p_mV,sound_p2p_adc,sound_bias_V,latitude,longitude,satellites,gps_fix,gps_speed_kmh,gps_utc,location_source");
  f.flush();
}

bool startSession(){
  if(sessionState!=STATE_IDLE || !sdReady)return false;
  if(!ensureLogDir())return false;
  sessionId=findNextSessionId();
  String path=sessionPath(sessionId);
  sessionFile=SD.open(path.c_str(),FILE_WRITE);
  if(!sessionFile)return false;
  writeCsvHeader(sessionFile);
  measurementCount=0; accumulatedRunMs=0; runStartedMs=millis(); lastMeasureMs=millis()-intervalMs; lastFlushMs=millis(); sessionState=STATE_RUNNING;
  return true;
}
void pauseSession(){ if(sessionState==STATE_RUNNING){ accumulatedRunMs+=(uint32_t)(millis()-runStartedMs); sessionState=STATE_PAUSED; if(sessionFile)sessionFile.flush(); } }
void resumeSession(){ if(sessionState==STATE_PAUSED){ runStartedMs=millis(); lastMeasureMs=millis()-intervalMs; sessionState=STATE_RUNNING; } }
void stopSession(){ if(sessionState==STATE_RUNNING)accumulatedRunMs+=(uint32_t)(millis()-runStartedMs); if(sessionFile){sessionFile.flush();sessionFile.close();} sessionState=STATE_IDLE; }

void logMeasurement(){
  if(sessionState!=STATE_RUNNING || !sessionFile)return;
  readSensors();
  DateTime now=rtcReady?rtc.now():DateTime(2000,1,1,0,0,0);
  double lat=0,lon=0; const char* locSource; bool hasPos=selectedPosition(lat,lon,locSource); bool gpsFix=validArduinoFix();
  measurementCount++;
  sessionFile.print(measurementCount);sessionFile.print(',');sessionFile.print(formatDateTime(now));sessionFile.print(',');sessionFile.print(elapsedSessionMs());sessionFile.print(',');
  if(isnan(liveSoundMv))sessionFile.print("");else sessionFile.print(liveSoundMv,1);sessionFile.print(',');
  sessionFile.print(liveSoundAdc);sessionFile.print(',');if(isnan(liveSoundBiasV))sessionFile.print("");else sessionFile.print(liveSoundBiasV,3);sessionFile.print(',');
  if(hasPos){sessionFile.print(lat,6);sessionFile.print(',');sessionFile.print(lon,6);}sessionFile.print(',');
  sessionFile.print(gps.satellites.isValid()?gps.satellites.value():0);sessionFile.print(',');sessionFile.print(gpsFix?1:0);sessionFile.print(',');
  if(gps.speed.isValid())sessionFile.print(gps.speed.kmph(),2);sessionFile.print(',');
  if(validGpsUtc()){char utc[24];snprintf(utc,sizeof(utc),"%04d-%02d-%02d %02d:%02d:%02d",gps.date.year(),gps.date.month(),gps.date.day(),gps.time.hour(),gps.time.minute(),gps.time.second());sessionFile.print(utc);}sessionFile.print(',');sessionFile.println(locSource);
  if((uint32_t)(millis()-lastFlushMs)>=1000){sessionFile.flush();lastFlushMs=millis();}
}

// ---------- HTTP ----------
String queryValue(const String &url,const String &key){
  int q=url.indexOf('?'); if(q<0)return ""; String qs=url.substring(q+1); String needle=key+"="; int p=0;
  while(p<qs.length()){int amp=qs.indexOf('&',p);if(amp<0)amp=qs.length();String part=qs.substring(p,amp);if(part.startsWith(needle))return part.substring(needle.length());p=amp+1;}return "";
}
String routeOnly(const String &url){int q=url.indexOf('?');return q<0?url:url.substring(0,q);}
void sendHeaders(WiFiClient &c,int code,const char* type,int32_t length=-1,const char* extra=nullptr,const char* cacheControl="no-store"){
  c.print("HTTP/1.1 ");c.print(code);c.println(code==200?" OK":code==400?" Bad Request":code==404?" Not Found":" Error");
  c.print("Content-Type: ");c.println(type); if(length>=0){c.print("Content-Length: ");c.println(length);} if(extra)c.println(extra); c.print("Cache-Control: "); c.println(cacheControl); c.println("Connection: close"); c.println();
}
void sendText(WiFiClient &c,int code,const String &s,const char* type="text/plain; charset=utf-8"){sendHeaders(c,code,type,s.length());c.print(s);}
void sendOk(WiFiClient &c){sendText(c,200,"OK");}

float estimateLoggedMB(){
  if(!sdReady)return -1;
  uint64_t bytes=0;
  File dir=SD.open(LOG_DIR); if(dir){for(File f=dir.openNextFile();f;f=dir.openNextFile()){if(!f.isDirectory())bytes+=f.size();f.close();}dir.close();}
  return max(0.0f,SD_NOMINAL_CAPACITY_MB-(float)bytes/1048576.0f);
}

void sendStatus(WiFiClient &c){
  if((uint32_t)(millis()-lastSensorReadMs)>1000)readSensors();
  DateTime now=rtcReady?rtc.now():DateTime(2000,1,1,0,0,0);double lat=0,lon=0;const char* source;bool pos=selectedPosition(lat,lon,source);
  sendHeaders(c,200,"application/json; charset=utf-8");c.print('{');
  c.print("\"state\":\"");c.print(stateName());c.print("\",");c.print("\"sessionId\":");c.print(sessionId);c.print(',');c.print("\"elapsed\":");c.print(elapsedSessionMs()/1000.0,1);c.print(',');c.print("\"count\":");c.print(measurementCount);c.print(',');c.print("\"intervalMs\":");c.print(intervalMs);c.print(',');
  c.print("\"sensorType\":\"MAX4466\",");c.print("\"sensorReady\":");c.print(sensorReady?"true":"false");c.print(',');c.print("\"soundP2PmV\":");if(isnan(liveSoundMv))c.print("null");else c.print(liveSoundMv,1);c.print(',');c.print("\"soundP2PAdc\":");c.print(liveSoundAdc);c.print(',');c.print("\"soundBiasV\":");if(isnan(liveSoundBiasV))c.print("null");else c.print(liveSoundBiasV,3);c.print(',');
  c.print("\"rtcReady\":");c.print(rtcReady?"true":"false");c.print(',');c.print("\"rtcSynced\":");c.print(rtcSynced?"true":"false");c.print(',');c.print("\"rtcTime\":\"");c.print(formatTimeOnly(now));c.print("\",");c.print("\"sdReady\":");c.print(sdReady?"true":"false");c.print(',');c.print("\"sdFreeMB\":");c.print(estimateLoggedMB(),1);c.print(',');
  c.print("\"gpsSeen\":");c.print(gpsSeen?"true":"false");c.print(',');c.print("\"gpsFix\":");c.print(validArduinoFix()?"true":"false");c.print(',');c.print("\"gpsUtcValid\":");c.print(validGpsUtc()?"true":"false");c.print(',');c.print("\"satellites\":");c.print(gps.satellites.isValid()?gps.satellites.value():0);c.print(',');c.print("\"positionValid\":");c.print(pos?"true":"false");c.print(',');c.print("\"latitude\":");c.print(lat,6);c.print(',');c.print("\"longitude\":");c.print(lon,6);c.print(',');c.print("\"locationSource\":\"");c.print(source);c.print("\"}");
}

bool parseCsvTimestamp(const String &line, DateTime &out){
  int a=line.indexOf(','); if(a<0)return false; int b=line.indexOf(',',a+1); if(b<0)return false; String s=line.substring(a+1,b); if(s.length()<19)return false;
  int y=s.substring(0,4).toInt(),mo=s.substring(5,7).toInt(),d=s.substring(8,10).toInt(),h=s.substring(11,13).toInt(),mi=s.substring(14,16).toInt(),se=s.substring(17,19).toInt();
  if(y<2020||mo<1||mo>12||d<1||d>31)return false; out=DateTime(y,mo,d,h,mi,se); return true;
}

struct SessionMeta{uint32_t id=0,count=0;uint32_t size=0,duration=0;String start="";};
bool sessionMetaFromFile(File &f,uint32_t id,SessionMeta &m){
  m.id=id;m.size=f.size();m.count=0;String line="";DateTime first,last;bool gotFirst=false,gotLast=false;bool header=true;
  while(f.available()){
    char ch=(char)f.read();
    if(ch=='\n'){
      line.trim(); if(header){header=false;} else if(line.length()){m.count++;DateTime dt;if(parseCsvTimestamp(line,dt)){if(!gotFirst){first=dt;gotFirst=true;m.start=formatDateTime(dt);}last=dt;gotLast=true;}}
      line="";
    } else if(ch!='\r' && line.length()<220) line+=ch;
  }
  if(line.length()&&!header){m.count++;DateTime dt;if(parseCsvTimestamp(line,dt)){if(!gotFirst){first=dt;gotFirst=true;m.start=formatDateTime(dt);}last=dt;gotLast=true;}}
  if(gotFirst&&gotLast){int64_t diff=(int64_t)last.unixtime()-(int64_t)first.unixtime();if(diff>0)m.duration=(uint32_t)diff;}
  f.seek(0);return true;
}

void sendSessions(WiFiClient &c){
  sendHeaders(c,200,"application/json; charset=utf-8"); c.print("{\"sessions\":["); bool firstOut=true;
  if(sdReady){File dir=SD.open(LOG_DIR);if(dir){for(File f=dir.openNextFile();f;f=dir.openNextFile()){
    if(!f.isDirectory()){String n=String(f.name());int p=n.lastIndexOf('/');if(p>=0)n=n.substring(p+1);if(n.startsWith("S")&&n.endsWith(".CSV")){uint32_t id=n.substring(1,n.length()-4).toInt();SessionMeta m;sessionMetaFromFile(f,id,m);if(!firstOut)c.print(',');firstOut=false;c.print("{\"id\":");c.print(m.id);c.print(",\"count\":");c.print(m.count);c.print(",\"size\":");c.print(m.size);c.print(",\"duration\":");c.print(m.duration);c.print(",\"start\":\"");c.print(m.start);c.print("\"}");}}
    f.close();}dir.close();}}
  c.print("]}");
}

void sendDownload(WiFiClient &c,uint32_t id){
  if(!sdReady){sendText(c,404,"SD niet beschikbaar");return;}String path=sessionPath(id);File f=SD.open(path.c_str(),FILE_READ);if(!f){sendText(c,404,"Bestand niet gevonden");return;}
  String disposition="Content-Disposition: attachment; filename=\"DataLogger_meetsessie_"+String(id)+".csv\"";sendHeaders(c,200,"text/csv; charset=utf-8",f.size(),disposition.c_str());uint8_t buf[256];while(f.available()){int n=f.read(buf,sizeof(buf));if(n>0)c.write(buf,n);readGps();}f.close();
}

void serveManual(WiFiClient &c){
  sendHeaders(c,200,"text/html; charset=utf-8",(int32_t)MANUAL_RAW_LEN,nullptr,"public, max-age=300");
  static uint8_t history[4096];
  uint32_t histPos=0;
  size_t ip=0;
  uint8_t outBuf[192];
  size_t outLen=0;
  auto emitByte=[&](uint8_t b){
    history[histPos & 4095]=b;
    histPos++;
    outBuf[outLen++]=b;
    if(outLen==sizeof(outBuf)){
      c.write(outBuf,outLen);
      outLen=0;
      readGps();
    }
  };
  while(ip<sizeof(MANUAL_LZ) && c.connected()){
    uint8_t ctrl=MANUAL_LZ[ip++];
    if((ctrl&0x80)==0){
      uint16_t n=(uint16_t)ctrl+1;
      for(uint16_t j=0;j<n && ip<sizeof(MANUAL_LZ);j++)emitByte(MANUAL_LZ[ip++]);
    }else{
      if(ip>=sizeof(MANUAL_LZ))break;
      uint8_t len=((ctrl>>4)&0x07)+3;
      uint16_t off=((uint16_t)(ctrl&0x0F)<<8)|MANUAL_LZ[ip++];
      for(uint8_t j=0;j<len;j++){
        uint8_t b=history[(histPos-off)&4095];
        emitByte(b);
      }
    }
  }
  if(outLen)c.write(outBuf,outLen);
  c.flush();
}

void serveHome(WiFiClient &c){
  const size_t total = sizeof(INDEX_HTML) - 1;
  sendHeaders(c,200,"text/html; charset=utf-8",(int32_t)total,nullptr,
              "public, max-age=300, stale-if-error=604800");

  size_t sent = 0;
  const size_t CHUNK = 768;

  while(sent < total && c.connected()){
    size_t remaining = total - sent;
    size_t n = remaining < CHUNK ? remaining : CHUNK;

    size_t written = c.write(
      reinterpret_cast<const uint8_t*>(INDEX_HTML) + sent,
      n
    );

    if(written == 0){
      delay(2);
      continue;
    }

    sent += written;
    readGps();
    delay(1);
  }

  c.flush();
}

void handleRequest(WiFiClient &c,const String &url,const String &method){
  String route=routeOnly(url);if(route=="/handleiding"){serveManual(c);return;}
  if(route=="/"){serveHome(c);return;}
  if(route=="/ping"){sendText(c,200,"DataLogger OK");return;}
  if(route=="/api/status" || route=="/status"){sendStatus(c);return;}
  if(route=="/api/sessions" || route=="/sessions"){sendSessions(c);return;}
  if(route=="/api/start" || route=="/start"){if(startSession())sendOk(c);else sendText(c,400,"Starten mislukt");return;}
  if(route=="/api/pause" || route=="/pause"){if(sessionState==STATE_RUNNING){pauseSession();sendOk(c);}else sendText(c,400,"Niet actief");return;}
  if(route=="/api/resume" || route=="/resume"){if(sessionState==STATE_PAUSED){resumeSession();sendOk(c);}else sendText(c,400,"Niet gepauzeerd");return;}
  if(route=="/api/stop" || route=="/stop"){if(sessionState!=STATE_IDLE){stopSession();sendOk(c);}else sendText(c,400,"Geen actieve sessie");return;}
  if(route=="/api/interval" || route=="/interval"){
    long ms=queryValue(url,"ms").toInt();
    if(ms<=0){float sec=queryValue(url,"seconds").toFloat(); if(sec>0)ms=(long)(sec*1000.0f+0.5f);}
    if(ms>=50 && ms<=2147483000L){intervalMs=(uint32_t)ms;sendOk(c);}else sendText(c,400,"Interval moet minimaal 50 ms zijn");return;
  }
  if(route=="/api/time"){
    int y=queryValue(url,"y").toInt(),mo=queryValue(url,"mo").toInt(),d=queryValue(url,"d").toInt(),h=queryValue(url,"h").toInt(),mi=queryValue(url,"mi").toInt(),s=queryValue(url,"s").toInt();
    if(rtcReady&&y>=2024&&y<=2100&&mo>=1&&mo<=12&&d>=1&&d<=31&&h>=0&&h<24&&mi>=0&&mi<60&&s>=0&&s<60){rtc.adjust(DateTime(y,mo,d,h,mi,s));rtcSynced=true;sendOk(c);}else sendText(c,400,"Ongeldige tijd");return;}
  if(route=="/api/delete"){uint32_t id=queryValue(url,"id").toInt();if(sessionState!=STATE_IDLE&&id==sessionId){sendText(c,400,"Actieve sessie kan niet worden verwijderd");return;}String path=sessionPath(id);if(sdReady&&SD.exists(path.c_str())&&SD.remove(path.c_str()))sendOk(c);else sendText(c,404,"Bestand niet gevonden");return;}
  if(route=="/api/download"){
    uint32_t id=queryValue(url,"id").toInt();
    if(sessionState!=STATE_IDLE && id==sessionId){sendText(c,400,"De actieve sessie kan pas na stoppen worden gelezen");return;}
    sendDownload(c,id);return;
  }
  if(route=="/download"){
    if(sessionState!=STATE_IDLE){sendText(c,400,"Downloaden kan pas nadat de actieve meetsessie is gestopt");return;}
    sendDownload(c,queryValue(url,"id").toInt());return;
  }
  sendText(c,404,"Niet gevonden");
}

void handleWebClient(){
  WiFiClient c = server.available();
  if(!c) return;

  c.setTimeout(1200);

  uint32_t started = millis();
  String line = "";

  while(c.connected() && (uint32_t)(millis() - started) < 2000){
    readGps();

    if(c.available()){
      char ch = (char)c.read();

      if(ch == '\n') break;
      if(ch != '\r' && line.length() < 500) line += ch;
    } else {
      delay(1);
    }
  }

  if(line.length()){
    int s1 = line.indexOf(' ');
    int s2 = line.indexOf(' ', s1 + 1);

    if(s1 > 0 && s2 > s1){
      String method = line.substring(0, s1);
      String url    = line.substring(s1 + 1, s2);

      uint32_t headerStart = millis();
      while(c.connected() && (uint32_t)(millis() - headerStart) < 2500){
        readGps();

        if(c.available()){
          String h = c.readStringUntil('\n');
          if(h == "\r" || h.length() <= 1) break;
        } else {
          delay(1);
        }
      }

      if(method == "GET" || method == "POST"){
        handleRequest(c, url, method);
      } else {
        sendText(c,400,"Alleen GET en POST ondersteund");
      }
    }
  }

  delay(2);
  c.stop();
}

void setup(){
  Serial.begin(115200); delay(200);
  Wire.begin(); Serial1.begin(GPS_BAUD);
  analogReadResolution(12); pinMode(SOUND_PIN,INPUT); rtcReady=rtc.begin();
  if(rtcReady){if(!rtc.isrunning()){rtc.adjust(DateTime(F(__DATE__),F(__TIME__)));rtcSynced=false;}else{DateTime n=rtc.now();rtcSynced=n.year()>=2024&&n.year()<=2100;}}
  sdReady=SD.begin(SD_CS_PIN); if(sdReady)ensureLogDir();
  readSensors();
  int ap = WiFi.beginAP(WIFI_SSID, WIFI_PASS);

  Serial.print("WiFi AP starten... status=");
  Serial.println(ap);

  uint32_t wifiWaitStart = millis();
  while(WiFi.status() != WL_AP_LISTENING &&
        WiFi.status() != WL_AP_CONNECTED &&
        (uint32_t)(millis() - wifiWaitStart) < 10000){
    delay(100);
  }

  if(WiFi.status() != WL_AP_LISTENING &&
     WiFi.status() != WL_AP_CONNECTED){
    Serial.println("WAARSCHUWING: WiFi Access Point is niet correct gestart.");
  }

  server.begin();

  Serial.println("\nDataLogger Toolkit 1 gestart");
  Serial.print("WiFi status: ");
  Serial.println(WiFi.status());
  Serial.print("WiFi: ");
  Serial.println(WIFI_SSID);
  Serial.print("Wachtwoord: ");
  Serial.println(WIFI_PASS);
  Serial.print("Open: http://");
  Serial.println(WiFi.localIP());
}

void loop(){
  readGps();
  uint32_t now=millis();
  if(sessionState==STATE_RUNNING && (uint32_t)(now-lastMeasureMs)>=intervalMs){lastMeasureMs+=intervalMs;logMeasurement();}
  else if(sessionState!=STATE_RUNNING && (uint32_t)(now-lastSensorReadMs)>=1000)readSensors();
  handleWebClient();
}
