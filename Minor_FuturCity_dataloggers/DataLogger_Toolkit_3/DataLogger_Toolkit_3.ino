#include <WiFiS3.h>
#include <Wire.h>
#include <SPI.h>
#include <SD.h>
#include <RTClib.h>
#include <Adafruit_SHT31.h>
#include <TinyGPSPlus.h>

// =========================
// DataLogger Toolkit 3 - UNO R4 WiFi
// Hardware: Keyes Logging Shield + GPS + SHT31 + JL-FS2
// GPS: Air530Z on Serial1 (UART)
// SHT31: I2C 0x44; JL-FS2 voltage output op A0
// RTC: DS1307 I2C 0x68
// SD: Keyes shield CS pin 10
// =========================

const char WIFI_SSID[] = "Arduino-Logger-03";
const char WIFI_PASS[] = "Logger2026!";
const uint8_t SD_CS_PIN = 10;
const uint32_t GPS_BAUD = 9600;
const char LOG_DIR[] = "/DATALOG";
const float SD_NOMINAL_CAPACITY_MB = 32768.0f; // 32 GB kaart; vrije ruimte is een benadering op basis van gelogde bestanden.

WiFiServer server(80);
RTC_DS1307 rtc;
Adafruit_SHT31 sht31 = Adafruit_SHT31();
TinyGPSPlus gps;

bool sdReady=false, rtcReady=false, shtReady=false, rtcSynced=false;
bool gpsSeen=false;
const uint8_t WIND_PIN=A0;
float liveTemp=NAN,liveHum=NAN,liveWind=NAN,liveWindVoltage=NAN;
uint32_t lastSensorReadMs=0;

enum SessionState : uint8_t { STATE_IDLE, STATE_RUNNING, STATE_PAUSED };
SessionState sessionState=STATE_IDLE;
uint32_t sessionId=0, measurementCount=0, intervalMs=1000;
uint32_t runStartedMs=0, accumulatedRunMs=0, lastMeasureMs=0, lastFlushMs=0;
File sessionFile;

// Exact HTML-handleiding, lossless gecomprimeerd om flash te besparen.
static const uint32_t MANUAL_RAW_LEN=4029;
static const uint8_t MANUAL_LZ[] = {
  16,60,33,100,111,99,116,121,112,101,32,104,116,109,108,62,10,60,144,7,36,32,108,97,
  110,103,61,34,110,108,34,62,60,104,101,97,100,62,60,109,101,116,97,32,99,104,97,114,
  115,101,116,61,34,117,116,102,45,56,128,28,160,22,21,110,97,109,101,61,34,118,105,101,
  119,112,111,114,116,34,32,99,111,110,116,101,110,128,38,12,119,105,100,116,104,61,100,101,
  118,105,99,101,45,160,13,16,44,105,110,105,116,105,97,108,45,115,99,97,108,101,61,49,
  34,128,112,35,116,105,116,108,101,62,84,111,111,108,107,105,116,32,51,32,194,183,32,87,
  105,110,100,32,101,110,32,107,108,105,109,97,97,116,60,47,176,36,4,10,60,115,116,121,
  144,8,24,58,114,111,111,116,123,45,45,110,97,118,121,58,35,51,52,51,70,53,56,59,
  45,45,111,114,128,182,8,101,58,35,70,67,66,48,51,49,128,17,4,99,114,101,97,109,
  128,16,4,54,70,50,69,65,128,16,9,112,97,112,101,114,58,35,102,102,102,128,13,6,
  105,110,107,58,35,50,51,144,2,128,14,12,109,117,116,101,100,58,35,54,54,55,48,56,
  53,128,16,2,108,105,110,128,74,4,68,67,69,49,69,144,91,4,103,114,101,101,110,128,
  47,26,70,65,69,55,66,125,10,42,123,98,111,120,45,115,105,122,105,110,103,58,98,111,
  114,100,101,114,45,128,18,15,125,98,111,100,121,123,109,97,114,103,105,110,58,48,59,102,
  129,9,8,45,102,97,109,105,108,121,58,73,129,20,3,114,44,65,114,128,253,26,44,115,
  97,110,115,45,115,101,114,105,102,59,98,97,99,107,103,114,111,117,110,100,58,118,97,114,
  40,192,179,6,41,59,99,111,108,111,114,192,19,128,169,1,41,59,144,144,16,45,104,101,
  105,103,104,116,58,49,46,54,125,46,116,111,112,123,240,62,192,43,145,17,208,61,160,231,
  3,112,97,100,100,144,164,5,52,52,112,120,32,50,128,5,5,125,46,119,114,97,112,128,
  164,0,120,177,146,7,58,49,48,53,48,112,120,59,192,181,3,97,117,116,111,160,92,3,
  32,104,49,123,160,192,128,229,3,101,58,52,56,240,35,3,48,32,48,32,128,15,176,38,
  1,98,123,240,170,209,129,5,41,125,109,97,105,110,240,99,240,99,224,99,224,152,0,50,
  128,74,160,152,1,32,55,128,35,7,125,115,101,99,116,105,111,110,240,217,208,217,161,186,
  1,41,59,177,107,1,58,49,128,48,5,115,111,108,105,100,32,176,30,145,29,208,29,8,
  45,114,97,100,105,117,115,58,50,144,115,224,103,0,54,240,128,144,192,144,29,2,125,104,
  50,193,171,0,45,128,202,16,58,48,125,46,103,114,105,100,123,100,105,115,112,108,97,121,
  58,144,13,0,59,144,5,3,45,116,101,109,128,18,2,116,101,45,128,235,15,117,109,110,
  115,58,114,101,112,101,97,116,40,50,44,49,102,128,148,5,103,97,112,58,49,50,145,17,
  3,99,97,114,100,130,25,240,163,240,163,240,163,240,163,1,58,49,128,248,224,163,1,49,
  53,176,67,4,108,108,111,117,116,192,70,5,45,108,101,102,116,58,128,25,240,75,241,102,
  242,60,130,184,129,236,2,55,101,55,240,77,144,90,240,109,160,109,160,163,0,100,144,59,
  0,114,208,95,194,41,5,99,57,52,98,52,98,240,80,176,80,9,49,102,49,125,116,97,
  98,108,101,123,209,198,1,48,37,208,84,128,57,5,108,97,112,115,101,58,208,9,0,125,
  131,220,13,116,100,123,116,101,120,116,45,97,108,105,103,110,58,144,187,240,144,145,141,227,
  40,3,116,116,111,109,241,33,241,33,130,58,7,99,111,100,101,44,112,114,101,178,124,195,
  60,12,117,105,45,109,111,110,111,115,112,97,99,101,44,224,10,0,125,144,39,240,180,131,
  157,4,48,50,57,51,66,194,254,4,119,104,105,116,101,240,128,146,0,241,16,225,125,7,
  111,118,101,114,102,108,111,119,178,248,6,64,109,101,100,105,97,40,242,185,1,55,48,128,
  184,1,41,123,178,25,242,12,242,12,128,71,1,102,114,243,48,227,48,0,51,147,33,192,
  80,4,32,112,114,105,110,145,210,132,27,240,175,161,99,242,240,131,246,0,107,131,233,13,
  115,105,100,101,58,97,118,111,105,100,125,125,60,47,196,238,1,60,47,181,131,144,66,181,
  143,9,101,114,32,99,108,97,115,115,61,34,128,122,133,135,2,100,105,118,208,17,147,222,
  128,18,8,98,62,68,97,116,97,76,97,98,149,79,17,77,105,110,111,114,32,70,117,116,
  117,114,67,105,116,121,60,47,98,128,71,0,49,245,115,229,115,0,38,245,114,128,32,6,
  60,112,62,65,114,100,117,128,61,6,32,85,78,79,32,82,52,128,37,10,70,105,32,43,
  32,74,76,45,70,83,50,128,9,145,14,14,101,114,97,116,117,117,114,47,108,117,99,104,
  116,118,111,128,5,132,164,0,101,129,215,4,43,32,71,80,83,128,6,2,82,84,67,128,
  6,7,83,68,60,47,112,62,60,47,128,171,128,6,176,197,128,219,148,42,149,216,177,8,
  128,151,5,50,62,68,111,101,108,128,34,0,50,144,128,240,163,5,114,101,103,105,115,116,
  133,134,3,114,116,32,119,128,172,3,115,110,101,108,144,103,0,44,240,133,1,117,114,150,
  52,1,114,101,129,160,4,105,101,118,101,32,240,146,176,146,4,46,32,84,105,106,166,88,
  128,153,3,45,108,111,99,144,40,1,32,119,146,22,7,110,32,97,97,110,32,105,101,145,
  90,14,109,101,101,116,112,117,110,116,32,116,111,101,103,101,118,128,5,1,100,46,144,188,
  0,10,241,103,1,61,34,146,13,241,121,144,18,147,253,161,121,145,74,161,99,12,98,114,
  62,48,226,128,147,51,48,32,109,47,115,192,250,240,49,240,49,193,79,3,117,105,116,103,
  131,158,240,59,11,128,147,53,32,86,32,97,110,97,108,111,111,128,23,240,64,240,64,160,
  64,5,83,116,97,110,100,97,128,14,0,32,130,104,3,101,114,118,97,129,63,176,68,1,
  49,32,240,120,240,56,240,169,1,70,105,208,42,193,233,3,45,76,111,103,132,32,2,45,
  48,51,209,170,176,6,209,160,241,170,145,170,192,185,129,59,1,115,108,128,190,1,101,110,
  177,183,164,53,128,7,0,114,128,4,5,104,62,68,114,97,97,129,16,128,10,144,14,0,
  65,192,44,131,149,224,20,2,70,117,110,128,84,0,101,176,16,0,47,160,55,144,4,4,
  100,62,82,111,111,144,58,130,251,128,4,132,90,6,101,114,110,101,32,43,57,129,25,3,
  50,52,32,86,224,26,1,86,111,131,103,160,80,128,16,240,64,5,100,62,90,119,97,114,
  152,61,240,65,144,65,7,71,78,68,32,195,169,110,32,210,220,128,16,224,36,1,71,101,
  129,254,1,110,115,136,232,9,112,112,101,108,105,106,107,101,32,109,129,53,0,97,240,92,
  208,92,1,71,101,146,166,192,55,1,65,48,224,11,209,183,132,163,1,110,110,128,150,0,
  115,225,215,240,66,176,66,4,66,108,97,117,119,224,56,3,110,105,101,116,241,74,129,74,
  192,24,130,244,2,111,111,109,192,69,1,44,32,160,39,6,103,101,98,114,117,105,107,192,
  219,160,84,0,47,177,117,242,164,129,233,181,236,0,32,198,83,161,243,145,43,2,32,100,
  101,211,194,160,78,128,92,144,19,209,15,5,53,86,45,112,105,110,130,242,178,25,1,68,
  101,130,130,2,101,109,111,137,234,128,76,133,47,0,101,131,135,0,32,209,76,209,140,0,
  32,131,39,145,132,4,46,32,66,105,106,208,160,133,217,19,110,32,116,119,101,101,32,112,
  111,119,101,114,98,97,110,107,115,32,109,111,128,73,0,110,144,113,129,120,133,245,1,106,
  110,128,14,2,119,101,108,128,53,241,123,161,123,211,154,128,116,2,98,111,110,160,10,0,
  111,132,199,128,58,163,19,0,103,129,155,0,101,146,72,128,171,242,165,242,165,210,165,0,
  84,244,31,244,164,196,18,212,103,128,229,3,98,101,115,116,129,127,128,94,12,83,72,84,
  51,49,47,83,69,78,48,51,56,53,137,167,1,110,115,128,118,0,98,128,146,2,102,116,
  32,133,232,128,34,128,42,195,113,7,73,194,178,67,45,98,117,115,145,186,4,103,101,115,
  108,111,144,220,144,209,128,187,129,86,192,176,3,102,105,114,109,130,139,0,101,144,63,9,
  97,100,114,101,115,32,48,120,52,52,163,241,4,101,108,101,122,101,145,110,149,28,240,193,
  240,193,7,50,62,79,109,114,101,107,101,146,76,164,249,240,180,209,198,1,103,101,135,107,
  0,32,210,121,161,37,244,120,1,46,32,128,41,224,129,210,58,0,32,144,191,135,133,160,
  120,135,72,0,62,245,83,133,186,0,91,128,56,2,93,32,61,212,146,0,115,210,204,8,
  32,91,86,93,32,195,151,32,54,128,55,128,52,240,177,240,177,144,177,0,70,192,110,192,
  170,128,42,198,140,7,47,10,226,148,148,226,148,128,128,3,182,148,0,95,230,148,1,95,
  100,128,35,129,213,130,177,3,115,47,10,32,128,1,240,43,160,62,160,27,0,95,198,16,
  1,95,51,176,36,240,40,240,40,240,40,144,40,0,46,128,103,240,174,240,174,240,174,1,
  67,83,132,74,208,169,5,109,101,97,115,117,114,130,138,8,110,116,95,105,100,10,114,116,
  99,144,153,130,103,2,109,101,95,150,49,1,108,10,134,94,136,239,4,100,95,109,115,10,
  230,121,9,114,101,95,67,10,104,117,109,105,100,144,202,3,112,99,116,10,145,79,3,95,
  115,112,101,176,41,160,14,9,118,111,108,116,97,103,101,95,86,10,150,160,8,116,117,100,
  101,10,108,111,110,103,176,10,0,115,128,101,1,108,108,131,249,8,115,10,103,112,115,95,
  102,105,120,160,8,176,66,2,107,109,104,160,14,2,117,116,99,128,51,150,182,7,111,110,
  95,115,111,117,114,99,129,99,240,219,240,219,208,219,0,71,177,238,210,50,0,86,131,73,
  151,230,131,55,0,32,132,12,245,243,229,243,1,98,62,146,189,1,111,112,128,5,128,33,
  10,49,57,50,46,49,54,56,46,52,46,49,144,27,2,46,32,67,136,224,2,114,111,108,
  135,132,0,32,128,4,132,7,179,29,0,44,135,221,215,86,131,27,1,116,117,130,117,134,
  148,135,169,146,102,1,110,97,147,3,151,85,8,115,101,115,115,105,101,46,32,73,163,255,
  4,103,114,97,102,105,146,217,5,32,107,117,110,32,106,135,137,128,156,247,206,199,206,243,
  178,200,86,2,98,101,107,149,151,243,51,208,249,0,47,216,75,8,99,114,105,112,116,62,
  10,40,102,166,87,4,111,110,40,41,123,130,45,2,116,114,121,144,7,24,32,32,105,102,
  40,110,101,119,32,85,82,76,83,101,97,114,99,104,80,97,114,97,109,115,40,209,89,1,
  46,115,160,22,6,41,46,103,101,116,40,39,169,187,7,39,41,61,61,61,39,49,39,160,
  72,144,1,144,170,2,111,119,46,138,92,1,69,118,130,42,0,76,133,18,11,101,110,101,
  114,40,39,108,111,97,100,39,44,240,121,0,123,143,45,0,84,130,60,133,127,240,143,0,
  41,139,80,160,64,160,93,10,40,41,125,44,51,48,48,41,125,41,59,160,94,0,125,128,
  6,0,125,128,139,10,99,104,40,101,41,123,125,10,125,41,40,128,26,128,233,192,215,129,
  138,170,7,0,47,175,174
};

static const char INDEX_HTML[] = R"DATALOGGER(
<!doctype html><html lang="nl"><head><meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1,viewport-fit=cover"><meta name="theme-color" id="browserThemeColor" content="#343F58"><meta name="application-name" content="DataLogger"><meta name="apple-mobile-web-app-title" content="DataLogger"><meta name="apple-mobile-web-app-capable" content="yes"><link rel="icon" type="image/png" sizes="32x32" href="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAACAAAAAgCAYAAABzenr0AAAGFUlEQVR4nG2Xy4tlVxXGf2vtfapuVdftesRGJGAEEeIrdoxBMHaUDIwECYRMpBASRFFwJoKDoGOH+Qt0YCYZiYIBdaQhCopkYGvnYaM0+EijIklV3dfZaznYj7Nvtxcu99xzz17Pb33ru3L12qm7gDjg4AIi+Zr+k3wtAr51r/8y/S4iOJ7vFTOTrfoQqOPFCLRrpx1up8s998locyvbjyLdecDveqBECqj0psRzBi253kg1k0vkxYiIlsy8NzOd9e7dl7J85ApIjVNacNWZu5f+lFAll1dqGYt1mWLNMZYEpNhumUn3mAjaHZsC9epwsiq1Bp6DUhVUFWmGpQU5lb+3sJ1krWqsnr2hREsPqWjKyCy1raEtFisWqyUqMD84QFQxM6SWXqRURbayrv5EwByiVD90iXR5S3dCUETg/OKcBz70Ab7w+c/y2ht/5aWf/QpCQFEMK5MgVPh5s1GAzATi2P8o3eP8v2BUWS4X3Pfee3n+e9/m6HDObLbD0eGc77/wE+bzPTx1Cau0qbqzBU7Gh/aOGqS8Q3xXRVVhuVrz4AP3c3j5gLdu/4eLiyWPPvJxNAgpGYIQYiQOkRjCRCoTgreSilujWeMU2b4BZbZAJDQjOzsRVUgpZSuecJSz8wvchZ2dgWEIJLeu/ZVHMqzjnc57+pOetRxEMvpjCAwxoColOUdwUkqEAZ49fZL3vPtdvPTzV/jDjTfZHSJWAd27AKJsw6QFUp2HkIlmTBvcFVElhkAIWpDsuEMMymK15LlvfIVnTp8E4PHHPsmXvv4d/vb32+zu7N7Bjo2K+1dBbumbirBcbHj7nTPSmLrgpLXWLJtNZhxenvPopx7i7GzBP2//m3tODvno/e9nsVihqlusmGkfIjhtGfW0IcpyveLhhz7ClZNjXv7N71gs1miIrZT5SAaeoAzD0KhDRVmvE6P1/b+bEhoPVGBARvv5+YIvPv04z33zywjCb1+9zre++zzL/54jXpZSYUxVIYRIiJEQtRBbTrVOoRecbK1Y78aw7Qpx3JxhiDz1xGdYrzf8461/8fDHPsgnrn6Yd84ucDdSsrInMk40RoIGAKw4zqOrZW9QaLyygeNSqLjum0oO7k5QxcxJyQgxYO7szWaklEhmmHkDqaigZUOaOZYy36lqeyPZYc2zVkLv0h0+9VdkejTGkIMzwy0VmEjL0N1xM8ysrWJVJYRYGBHEy8x1Lde62zOqG86b835CpoAEFd0SJW6GpdRao6JoyJXJbgrSRbYSU2kKqJ+BSVy453JWIpFS0j4+d8dsJKURS5Z3qlZZVtmv4/uOkbVHfxUP7pn9fIIwZgkRIYSBEGLLIpfcMMt0LJKzrg7dra1bl07Kef6uxeWWoqkoGJOVma7GIOhAiLGBdRwTlqqOEERlYsnSlqmoUph9KkFWRDJRcdVjZhCC5tK3oPICGWKuwGYzsl5v8k4gV2e2u5PPt9ZKJ806jVMarlVKtWlwR4OwWCx5/eYtjo7m3HNyyGq15o+v3WR/b4frN24ypsTJ8WWOj+Zcv/Fn1usNZ+cr3vzLLeYH+5wczXn77II/vX6T3Z0Bs6IFmq4vVbl67dR9ooYclSrjuGF/NuOrzzzF++67lxd/9At++crvOT464vxiyWOffpAnPvcIb9y8xQ9e+DGWHI0DJ8dzvvbs01y5cswPX/wpL//6VeaX9spoToqx4e7qtdOpxj79KAKbMbFYrRFVxBKX9vdAlDgMnJ9dsFqvSOPI/GCPYRgIYSCZsFguMyh95ODSpZx9Zdtu0IAiSoVGHiLSrocYmM3mAKRxzKJTnDRuONifsb834OZlJQtmiaCRy/N9LI2Zsq1XVyW9wroudRv6JJYbEMt1Gsd8zwxqcO6MZdmYS8FtDWLETHCsEJsUfvPmoZOIRYN3OKfowUkXFjKqf0bavYxhLQzqaLcBrfe3rbYqDZdpU8S7BypJ5FI5Wbt3P9AU6tarC8wqd8nkXArImzaUlqDigtS/xl0bqj8pLemFW21QE5hSdeHEdmX7lKemHVLjrx4nDHTjKYVSvU6Flwy6w32k0xqfAJY5V7YqmjFkWxH8D13zZ1pmMqQiAAAAAElFTkSuQmCC"><link rel="apple-touch-icon" sizes="180x180" href="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAALQAAAC0CAYAAAA9zQYyAABGpklEQVR4nO29aZsct7Em+gKZWVt3s8nmLlFctMuWLdsz9jw+z5y5/2N+79yZ63PGtmzLWqyFmyjuW6+VlZmI+wFbYMmq6pYoNakKPsWuykQCkUjgxRuBAFJ89O//kwBAwIj5Qux/4c+akxQmdsftFf4MRUmin+EBsnnoXKSU7BS54yCmk2DX8qyEPiVYIndPUdo4q+iWFhzI5xWmpbAc8gXGSZYTmx+/O3Z2ibyECK+iWAHB6pj0WQpvg9WbrV/KFL6oAfBTeZ2ScrP56S8yl2YlK3lZpcwBnEc2C5oGqef1/BA05kDbnC6awGx0WkR/s2n67gQLoWuuhj3olB2s+oqJh6uMCIQVmFzixlNapPH3E5Y1G1CCe5uLmH33upTKhxqugmtWCL2SV0pKz5O1EITvRGSwQHAOyiSHeDGSLaBUyaUcUGPuyUlnHwBwZGGcOyzH3HNM75J0PkGvTSBcYf4uem6eiIKjevwQQb7+irAgkeQvXOqUtkaVFA9ayHDmOBMhDCfO5dOPoMS+CQBCyKC8+Jkk9pkpe85PZO0gIyuEXskrJaX9EvcsfkxEQNdLk5ahPiE8HV7ia/pQdgldFnsDKC0gO0IQqzXBx7isqh6tmFngwHBJOwLofQDJJaFBlFMtdyCjRGjE5KrPjRsiW3tsRMqMnku0B27D5MpfIfRKXikpYzzOOyl6/NFHkdgbkKNQy+RzJKQ5pMzzXETlc56XqJan8hqMLT1dMNrFo2VWTaZEdvB5Ac6QRH4Ax8sSzrTe8lYIvZJXSsp+9KXk2+JO18eq0hTR3J3RILT4E92O4J4knkdM/kXoX0+sB9InBSP8MQ9OS0KQTheXOq0Fc+p6Lk/+3u0sYOJZYDnH3idmFMyfVfMeFz/ChC0ga19kqic4bMizyFzjni0tM9rHrrJIDTacxc9hhdAreaWkTBA06OX91mwovEdFnNwhQZiXY+zkj/TxI4qR+rD8zPqkTc9O/Zo2Wb/JTVHRQfxCdKzX85JMowrv5rXoRhSliYVMPlzbnrRxcblkDGbT0/NdEDGfz9pftPzjiucdvIGxjMtK/1kh9EpeKSn7es+hQDCGr+DH4Ynv0a9kKvX+yGU8724X1UTGyZutj1i4V0ksDvM4jOmfKf5oddnjg39REnu9jlDeCqFX8kpJmczPc/7ieFXsSM1xm9AL0Csi+prz0Ubl5IDfU/M+HwzLcUGvF9GsFY/h0KghUt491/sQF5ArW1duXKVpYofhVll/PtHBXpH3LOV+xbaNiJ5ptup6BiCiXPXG9xF6rDKWU0YyxgBF+a380Ct5FaX0iJdDGPIGODtxKK9DHDnlcg4pUy6LFNgyEECpt0EXG6JsOAKw0YgXHLqnTfZkwFSfXIwAWZjqSclqdsE1npbb/JnyfaMHr9wej0SsS3CpyD+jOGrQZ5rxLkfVkQxEGRHumdrybPai93qbdoXQK3mlpEyQLfA9hxw2t+4slj6gOZTxehj3YwTjfA7JHRGWr8dwMd+fEvkhQuWWcMX0sfvcNX2uap9HDtKO4nYIC1iGw0Ze8+/nhlrGfZbkn6tJq3+Y4QqhV/JKSTJT+KKE2ArlDKWLEoc/l0L35DZy3oIF95rzuPSolvBKVm68KqPf8s/ln7Ho3XHhuG0uv5zXIVdCKHmvio7wDh3DR3ND95WXkb5TfV6jTPYrhF7JKyUu2i7b6nuCHvo6iID2YzojnKNij890qR5LIf75XLgnIybTcQqDOcz5LZ3rIOTFSTQXpcjsr/GEv28NI7JegZyVwqst8iUzu0Ik18a8OJLAbROUtHCBzDzJPcm4bfTaESBj24gkcWLXsUwIxlfeY/+sEHolr5SUQuhm73yLOffm0chTkMfhssgjHcXHRHKWnWIl94wOfR6e+VTb1FPmhgTziVNQbr78/uN9CpBDKY9o1Bs9OF/yhoofwCIndEbCMG8/doajzvLK9XtcohEMAnY3J3+tlhVCv3DhA+9KXrSUi5Okwv2SMQdM6OPCvAhp7EEPJ5y3yZmIrzE8c44Ccb/vUTCrWx4V0yGFABMrQn2pGPdkmfbOsNL36yOLADM7Aoa++JSj5z0lC2Xpe4g94f11eaQGvZJUiMgYKwAg9AYrknVNvpDB2TQ/jsv05ySlpj/BfkkuriOmUPFWCryfOMbkOF7Pw0p2zGTegQinYmQW7PqUnsacMO8lEIyI94Utp7sKse8y4uG2TsjCptBxJEJASKMrKUApEJFORy4lSOiPRWlpNXL3ySo9Qk+/B0k0ciUOH5G7SV4heWAm/mT9iXglk+A/ALPnRojqqaTtQ5Dw9gfg4nGSnVKDLIMHu0Low0vsAtMNWMoCUuhWpkAgRVDKPBrSzUIKASELEAHKGOIhaAj2WclRpBSBhWol5CzLVK9LR/n0/SsyMifsIdWPugt1ssAWJxT+YLzWL2BmEWQ5BCaXiaMOQhYoywpFUQAgdF2DRjVQpHQaAopCoCgkClFAAWg7hbZrGbpaZJeB/lo3k4kwaBujK3dSZ6uC+h9A5L8PY1YEr675YhLaNpCsDySeMNLt0JJpB0bJFUIvlKhL2xYqBAopIYQEgVDXNbquQ9e1UKp16EsECKXzEVJfU5QlZFFCFBKFTeRKS43klSwvmWg7LzFX7vMs8nRLPwrWc4/mq47zi1FqscUd287egLNnyX03WAUFBRAgZYGiLCCERDNrMD04wMH+PjrVYFBVGI6GKMsKAgJdpzCbzVBPWyhSKKsKa5MxRoMxSiGgOoVOKShSuhwh/e3ECuf4Y3KvOT/KcnLYZxBz7/j6Q/o9vresEHpJsdsxSrYcazaboWlaNLMGggibGxOc2FzD1smT2NjcwHA4BEigbVrs7x/g+c4enm1vY3f/AM2sASmFQVmhLEtIKfWGjcy4jBRYyRJSWgs42A2SLHe2FnDGqmXCwTGp9xyHtbkROzDXt7zE8SVAKd1LYxHCCcefiTpICBTSGnYK9XSKuq5RFiUunD+Hd96+ivfevorXXzuP9Y11VMMKpBTapsXBQY0nT5/j1rf38OXXN3Dr5h08f74N1XQYTyaoqgpCCCil0JEKeStDZr4DVDC6sq+5ffb83cUdJbx33g68Z7EHd10a/wx7dwvJGlbhORJRm5greftqhdALxbqQjPtICrRti9lshrZtcWJ9HW9cuohff/g+fvOrD/D2m1dw9uwpVIMBikJCkULXdGibDtu7e7j/4DGuXLqIv3/yBb744is8ePgE0+kUXddhOBxCSAlJjvD8tLf+EkrpQYmTWms96yPx/IxHj7DPOx90ID3oR+j5PZ93cZ8kUYo/QSbOAxYSUhF5Nfh8Z0hTtfsNgiBlASEBRYSpMQBPndzEh++/iz/8/tf43Ucf4PIbFzEeDU1DNgpQAVWUoCFhMh7iwrktXL18EdeuvI7/7+wW/u9f/oGbt7/DtK4BKTEYVPp6RToPB1rsHiJvhogjDXNegKTOYh+vtSP4iBlUovcPR3lyP3i4goSSnbN636AGJB6XuFx7zE9K8eP6+wqhF4rlzhJt16JuNDJvbm7gF++/g//nv/8Bf/j9r3D18msYDiUOpjPUdY2m7QAFuAYhgFJKbKxNcOrUBFsnT2A8HgICaLsON+/cRT2rAQGMhyPt0wbQkfoJ7/3lkxIRpoZ9MkSsmLrm/Alpv4t9vDlZzs+R88DER/L78eX9L9kRwPynzI0LqRFBEaGuG9RNgxOTCT5490389z/+Dn/8bx/hjUvnUUiB/f0ataEiRKQbtBAAJIgIDSnsTw8wogFObo7w6w/fQasUmrbDrFO4e+8BZtMZqmKAUhYQUur4ckW2T7g7OyoZ6WWnycONn+5yGXs/dCTRQJybQewfV5aXFUL3iq5wKU1jbFvUsxkKKXH+3Bn86hfv4be/eg9vXDqHQVng2fYu9g8O9KWCIIVkT8+GkxJ2ZjNMD6Y4fXoTJ0+M8eH7b2L7+Q4eP3mOvd19PH26g3o2A1W6UevJ8O6nqICXUlyD9hhpp2s12gl4DpNEulouylZkpH0r5FBB2AHn0ct0yqi8fBqbZWwxM7M92vchXN2iG57lfoUoMFMdZrMZiAgnT2zgrWuX8Yv33sKl186hKiTqWY22mYEIKKTxI7Oi7WwiCOjQousUptMa1XqJM6dP4IN3r+LOnft4+OAJ9vZnmM1mAATKooAQulPpWceIoeYN/dRxZEabeaNtWo8iLaAPdpEaTzHDzXvM+BRS/47b4W5LlN4oy3EVDz1HbHV1nULTtqiKAufPbOHNK5fwxqULWFsbYzqdYnd3D03bOj91ISWkkJDSfwohURQFpCxAAPYPptjb34cUwPmzW3jrzcu4/Mbr2NhYg+oITdNCKcOfV09paZGW+BKZDsm7sLVnRL/rN+XcIvyYaDJfALtW+DzcjDJluDhXYOHbYPW/vM7eQAs+XH+jpjSxFZ0idG0L6giT0QgXzp/BG5fO48yZkxgMKnRdh6ZpARImOMlnKEwewr7zDwQpgaKQIEWYzRoAhPX1MS5ePIvXL13AqZObKMtSzx52io2O5AYdcvWgP75YfUP2X/AApTD2gAg8RVzH4MPPRfUWeoJ4S/D1T/xBRqr4Dx+ZRSa3xeLT6gJWfb9PpASkhFIKbaeRcjIZ4/Spk9g6tYnRcABFhKbtoJSCkAJSLhrHCVJKlKVmem3bYTZrIaXA5uYazp87ha1TJzAaDvR5xVB6JUsJ25eDV1zIMS2H8Z3J/M6sZk79FZHP1B3NXLWgPVCE3vN6cZ+3JuDuc8qzKKaIdIyFFBgNh9jYWMPG2hiDUjuIOkVQAKSh5jx/YgVKaRFPY0gnBLpOh5hKKbAxGWHr1Do2N9cwGFbYPThA23VmZlIjjxIm3JTZIXZ04/czL7gpHrWECOve2xVgdkicSeSy4GVb+4QrCriIwDhGJadpr7cjkzg+tPJyLBAd3QwIKVFUJarKhoniyOgphe1qxiVnjMlBVeqJldLnr+IQ2u8l85pPXE5s1r0ckvFyeFk8gKY/CNZnGqN8KLlOnkrMm5fF5wUSmP/2Z6IhK4M0ukoBWQrIQuiwZbNWkAggBetyDrmh5dKR9mEgEhxXtatdFBGkMnyUKLRvkhoIa9mPTh59+Z2GtxkeC20XCRJ+lU0I36xcdlEYE5Qvsl/cmJPTBuH9hV4Tm3LFoZcQXkmEkJzNlUM8TLuKRamc3cuXqf1gRb6S4nfwz/XUBev3lqk8H2eg+KURmerpkVkL2PdJM2izfPov9X2fGAfNc3fuNXBeAfLM1P+VLI2/zu3jR+wNh85JYLwGwnqBtGvHGpXCknBB0CsDFHSXYjfI9Cd+j4JYWbm9lFPITHYUtSkz9Dl+3sS/8KqMQDq8Nh4Pc/7n8JrEJuC6RWsiVxx6oXCikD8vYDrAC4XHRc0rf6b/daC2c4sXrPePK6Vb+Rw5ObyvE6lpnJOFSUTuj560W2rRmpcAZwKEj8ub9+bB+eJnpwSUm1n0PNcjcuzD9QXxCS2LnM7RDnIwqH3fSq8OJ2If4WHOce7QgyOMjjqB3rtPwqA/X4Qr8g3dVp80iZIIS76GkV0d1Cj3ZrDDtv7myVEsoXn0a4XQL0A4NVn4wDLG3tzjgShTjtnyx/QBZcoWhZ6hlKbjeaLIG7NtxBQYqS+rlNl9E8j36gCplxDPcOd5GiM5wpDXb3CHOOQedqaoXg3ZbJqQfn8NEc228Zm0eH4OsGAc7LKnPSAM/XXDJY+MknQa4/+2/7wpah+KCswf10wJUFAoZImyKFGWJUopfZHRHh5E2h+uF/h2IFLwgyaD9UwbEBF/DerS8tzo+cyTpRc0cKSIHuIKoY8smnMcB/rJV4oXUkIUElIIKOpQ1x0OlNL7hFh+A0aVzMp1KSSEECiKwrgJVdJQXwbsLuMZHOvwDG/Gcsg54ix7kzIkuZ5LWWSwAyDrxr6zxRyNH4/O2ut7WpZfwQ1+k5Hu/IsIDnrc9d+tTzr4yzm0K4X9EDlThO0ShPQWOE8mX3GInw8RQUKHrJZFgaLSODWbzTCd1qjrhk0CCVjviJBAWRYYDAYYDwcoigEAAaU6qI5ASqO1jGJwfLmsprhHLNjPOzZE2TV90hd4nxGK2tcKoZcUW8WSf4TxUf9EMO2MQyEN0gqzqqaBUp0OZy0kTm5uYDgcYGBmOYkEOqXQtDM0swaztkVd1wAaFEXpdoESUoJesliSMukzHMQc+ongVLbLOAvcYIqJ3XUxEdGluTbggTJE0riXB78WROEFdGtJWyAImmPRZzJCYuvlkObjPRxRXVohxqjJ0WezLRjj484bIiDIuNaiaEV7zwSzR0hRAAKY1noJmIDA1uYmLl48h0uvX8C5M1tYX19DVVY6qKppsLOzi4ePnuC7ew9x/95D7O7to2tbDIZDVFUFkF5a0HVdMiIEarj/cpQ5xuSUd/t6XxIZMoaQPbRC6D7hzGNZAvljITXnwWYyZtY2aNsWTddhMh7h/JkzePetK3j3nau4duUSzp3ZwmQyRlVVUKTQNA12d/fx4OET3Pr2Hr7+5hZufXsX9x8+xnQ6w6wjyEIaQ/jlQeqkQVteGngREqRZJmvO+Xj/DHtowJ6THtrDpbLw3qMkhWVz1d2UNgkPy64hO4g28RXMyyG9MeWNK5GokFPXutTskiw7FMZ7sEqXzs8GCgHn/QDpvfKECXGdTqfoVIfNExv44J238LuPfoHf/Oo9XLt80VEOS0uE0IsWlOpQzy5je3cft759gE8/+xp//uun+OrrG3j2bBttJ1ENKhi/H2BWzcx/HtGznNNW5q9XWU5EVM4KoZcQb5TNh+AfyxMgbaCUFGjaTi8Ba1tsnljDB+9cxf/4t/+CP/zXX+Gdty5jMqrcdbb/CAGgKgBUWJuMsHVyAxcunMWZ06cwmYxQlQL//OwrPH62A9Vow7GQAiQFqDvevg4fy8EicBK/Ygyg1qKNuRQjU718iF2SxObGSeLt90WaZu7ewQQG1OxHXKDz7Vojy1vu3NdsubIUwhmGQpi1AFw3EZXkSTyslyaYECQ/EFowtBUvhHmHCgGkdLcqSwkIiU4RpvUMs6bB5ok1/PKDd/A//u2/4N//+DtceeMiRkPdmKlTaLvO1I3xlUs4D42UEqNS4u2rFzEZVxiUEq3q8MlnX+HZ9h6U6jAaDU1a/dx1WGu4Uyp/FLZzUxRWGc8TxF6l4OsyNk+UZIXQL5sIobciA1DXeiuy4bDC5UsX8fvffoj/9l9/jbeuXUJZSDRNi+nBFJ3SFEVI5rITvmEWUmAwqDAaD3H10nk0s1/g6fYOnm3vYHf/BqYHM1SlXRMp0XXHdxV6mToJNDyEM4gUpOlF32W41Fz3RvjTvUkg4zRIpzRsIgLgYzDTu/Dipogzyrld+E1UnHM8OL+04dWOY+dy8Vvqci2EO6d3R/LrOS1km7KkX+EC8jHZRAKztsH+tIaUhNfOn8FHv3wXv/voF3jrim7Mqu0wndaYta1ZsGtnP03NCb9GsekUVF2jqgoUZYlLr5/Hbz98H/fvP8TDh0/w3fQhZvUMg0EFWVX8CSXPIH73dl9EY/BUYkdbtCp/KX5t2tnPJB76x+d9L8LhYVeQt12H6XSGpm2xNhnh2pXX8eH7b+PNy69hMhmibVvs7u6hrvXWC9pPnQZPQWgerkihrhvs7h2gaRqMhxWuXX4N7711FZdeO4fJaIi20+sfldkNalkP248tR2vQOZ+ok9B4cu8VWS5jpJiqy+LoaH21lus63mt5LHEVbZ4Kfi26TedXg1BUvndAuBICTh3cbl/92DxEdNiUq8itkc7cBBx42VXsRWENwQbTWY1CSpw5s4W333wDb129hK3NEwABzaxB03V6QW5RanR2vhWvlOXPhTEAmq5D22o6cerUBq5efg3XrlzCyZMnQATM2lbTF9iRyT5b5l+PbOfQf5N/2hQfWEqshUtBeT8ThD5+khKiBWLdhgDatkXbtBgOBjh7ZguXXruAM2dOoigkZvUMs1ljFt9q3ttHEW0fkoWALLT7T6OwQlkInN7axGsXzmFz84QeGVoF1eoGLeXxbDpu1Xd6y/1OKE+3OT+2nNlCUsSz5gF6X/4uCY9ii/WN+Rxbf9cbDpkxy4NkpkTrfxbQM3aAH7bNRUIYj4HwupAAwnWA5DR11r/5n48WwdpJ6zoBHPfVHJXQtfotAuPREFsnN3F66xTW19cgCol21qKzVh9ST5TXnLwuBE09OkKnOtOgC6yvj3Hy5Amsr00gZQGlZuhUh4IEAAkF6fLhdcfLjTl0EttxiEjOUP8gW3fg5fByzONr1H++d/vXl1iU0qvBpQCGgwHWxmOzhW8BRWQogW5w88QRARU2PL3SXEGZyLvhcIDhYIDCILJSqhebjoO4WI5grZ+IGsGiO7DolBAiMBQ0FZcb/iK/Y+AvsO6FIKlBK75qOkjBVkpbfpopkLFj98WBmwNo9iOZDbQ/JIJCghHC163dm05AmAXjIvRHI65qztmlgX6NzkIIlGWJQVXprRWkDhnVt0vRHYZ2CYEhIxtJwkB/ASkKVLJAWRR6pbu7LbM7lesWIe/nz8Ev748SzLEq01iRqAFGo6n+ow++HAidEWvQCEME9bPUD0MqAaV0/IE+ptxyJGAJxBbLJPqeYhsRjuCDEXARdu41cEaOymztEoKCqce1e1lGuUyD5mO4CLkdi29YLCHXjd/fna+iHKH23BGGmxZmxqooC+Ps98ihlH43INmg9q5F2wEdOjfTZhHFPi6Lr54jCw/T/FxOx0V0iNeB9Vc774qpW0EsXsKiLP94Lu9Ju6EWQgQxJfGIaDt50m2cycH0UQQloF8Yyq/hwwgUHJznemJUH/HT5gO4yB3PyZxEzmJ7qTg0ADv82gkCAswWtwCRWaTkXkEM2IkIG/dQiAKi8DsVzSvn2IptAVkYPqTe2ToIDRKN2mYp2HEmzkyyDTp4kxGz3r1F2ceD+rtsvNNNdDovQpdlkVNKgbIsICD1i3uaBrNZg7Zl8bpm9TQRoSwKVINKGzVFiQKEDh06xfZaFhI29thsh+Q/gn2sQhn1+25hXhuw7m3Np4U7ECAtI/OuDmwcibRJzDETSZcqk6KzjcH2vzXiur0KyabRT01jst20XcSUPKyMpYWCUTA/r9GL7+5YfOb4I7T0kyhECnXdmtBHvcnh2toYg8EAVVmaXfP1K4frmd44vGlbTKcHen/mUu/PLKU3xmzA0I8jS8DcIfi7sBT6BbqEKfocdyljizKMUV0kvgdxP4Rg52L/RPKL4HYasj5Nzrvtq9QAmPhd/QaqyXiM82dP47WLF3Du7BbWJmOURQGlCHU9w/PdHTx8+AT37j/A40ePcDCdolUFRsMRirICFOndP4n8ahFhFIpnArmjIKaiFAMWm/1LatDXl31nNwEgMzB4d7PwyCt0uKj2vnDUtgjN47Jjvo+M8WmMPHaLRDo+RJGABGlPCij0rStN17x/gz3z4KHlt7ZJduMHzLS8QVphvVZprQWjO9nHERkoRo4vQgsBKSQIOhjdvui9qiqcP3saV994DW+/dQXXrryBc2dPYW08Mu9DAepZg+c7u3jw8DFu3bqDb67fxO073+HRk+c4qGuUXYeqrPSOovjh0OeHRbCkacJNMAu8eGgG8HJgcih+99HeWbM5wkzWrAdgbmYMx9mSInfQoE5H+j3YbaewNhnh8usX8ZsP38dvf/Uu3rx2CWdPn8SgKlCYd5gQ9KvQ6lmLaV3j8aOn+ObGHfztky/w17//Ezdvf4d6NgOEwKAaoCgKdMr6rLn+1sJXBrHMseQWBVxMiL0XSn06+odvoHZPOzMOOT7sUNbyahYhJyAhhPJvCnARgQwJhQnEN1t8+cGFAoWI/fQc2t6P4cmKeTf4SJXhIP1NJqqJiBZnZwqdjWYvCSud+Mno6LFDaAFoiwe6YTZNAwJhfTLGtSuv4/e//RB//P1v8It3r2Lr5ERfRGZjcrZUf2NNG5EXzp7GhQvncWrrJKqqhBACN27fwazRL+YZyZHh1D8Wjz6seIphjUjd2fWL7u0igxcH1vOMteMnh2rQsc0ZSgbdsufzPMmes5Z61ym0Su/ms7E+xtvXLuGPv/8I//aHj/D+O1exNhnqhtx2+rUQYH5dg2w66KbA+XMnMRq+i+GgwHBYAhK4fvMO6tkMUhYYVBVKt8EKmYbirXkFmP2cYdDX3wP3J+s9QoltSWfz8Jjidj4luPhmwbwbAR+2XhD3QwJSG7FuBY3d4d9EzEmYyETSPJ2sXRBVOHdXW2asoMy+eP6ZeeJjkZp/2PMOPF9pWzgMXHgrLDZc0jM+WF7/PXYIrYXMCuYGVVXiwrkt/OaX7+CPv/8VfvHuVYzHOub3YG8fs8ZMpJjOQKQcQ1BQqKoS6+tr2Npcx4cfvI2u7bC9s4udnT3cufsQU/Py+UElk+X6ParN+3kkyXrbggRmIiWa7DGb+SbXHsJR8spJmcRWOB5LvcfySO0tVt2fmWXKs/fJTdaeL2mjToGUQNvqN0Rtba7j/beu4LcfvYf337miG/Nshv3pFG3bQdkAdr7KQWjk7BSBZi329/YhJmOc3FjDe29dxaNHT/Do8RPs7Ozh2fY+2qYFDQeB6e+iyJzT1nglXIyIScX5M0L/rjCc2/FVCyaWHxOL7ZbCbVyTeyuV3lM0Omad0dw3bI/Z+idEkyL+ePJMwqcJ213S85bsmLhuwKV29CgeFaIH76yujGfDlhi3FXJ16FdUUVS5xy6oVSkd79upDqNBidfOncZ771zB29fewPraBF3X4dn2Dvb3p+iIdDwDM/i9F0D/7roOu3v72NnZRdd0OLm5gXeuXcF7b1/DuTNbOoa4bdA0Gp3743y5cZjK9/GUCJlvVG4GJdqeKdfEflz5qcvvF2kfROIkYjwujNXtl4zx6yQZBhnoO5ZFAqoDZk0HQOLE2jreeO0C3rp6CefOnAIANI2dGRQoyhJFWfgZMucp0B+7qBPQy/1nbYOqLHD+/BbeuvIGLr12AeuTsZ58qWcg0hFm1sInY2wSKfObXIyIv2nry2bT6lF92UN8aAv284B1WIjwOOfVmZ1PLZclwTml4cP2OOe6BuIoiPKLVpSEDhQzkLDRxIwU/Jk6dHZGgh913S8zIrk1Q0aBoL0I1wyy20r77NkqI9ewdE7HEKG1i05KiY2NdVw4dxrnz2xhOBygbTvUUx2/odfXsdUYrAJsdfu3t0p0SqGua7Rtg8l4iAvntnDxwlmcOLGuX0w/a6AU0P/qxoyfqseFtZTMJbqWIX+/x/N9+L0b6dKjx1rKWMWlnk1CoufdaJyb793xzpGQ2tYm6lCUJSZrY2xunsDmiXWURYm6nqFrO0ihGzIplW1n9pjlwXZ3eqU6gBSGgxInN9dx9vRJbG6sQ4pHaNpO8zFhUYNc1B6URxIdrKM/Ioma66mOpAo0/IX/MtzZcma7Q6zzNzgfCmO6vjA7WpB95wpDTPeT68RO+9HCjxqws7VSxCeZ3cEbBadH0a0ntlXeIgv1nde+QkA7dghth2opJaqqQjWoUBR6PxzVdRpFpR727OoK09J6RZjV0jCrPQSAYVVhfW2M8Xis81cEO+UL+/88muU6zQ8srkW5Py8BLh4fKR2XzfSqaMImsDb5Gctl3C+a2+9SsesQlQBIQigBSRodZFG4PdmslUvM66DpmI0E84VaQ9/xN6snaUTTqz2GGAwGkEUBoA3ilEmZMYT0qCFIaKS2XDr+Z/zfPP7B1xJfDGa9GoCw7wcPEqceDiEivuj8fB6j7a1bbmknJRP+Hj46U0f2h/QnA38y057FmdhRCjbWxI4VwWX5lpDfxaRP+IO111idQsQ/fggdiAIpHot7SKyam9waW/7zY8pctsatrV6RixIcUpFM+S+h+L3t5vaP8Fxmvsajoa2MnuyCtyvZY9bNIqH9LlJzCAEKaFrOJ+odCjEnM9fw+AjnJZAIljBZ9HcGnmPRBq31LxVgsgKR9N6CQAU7tAn3N8eRAfM+FdaAEqdEriq9+8F8IiNCATa+RBiY7mNPfn8NrUPgSbF737lnwEcEO8yEYB6MlKxOkqWF7C7jLQxzOgKsnlkB8aXHEKGP4jJYTuxofRT5YTX6ESDw+1SjiLWTyHp/jiGSz536zmPe8ufnC6tx27uJ4GwzGEQWujqjK2D57Xy2Ltz/GuntC3J4VBvgCuUcmqO0sMSU3Men84c9ffblcrX0TqJs/R+jDY73coSEj6WgpLr0iKE/vhb4gJvYFlHtw+br6sfUOTGPs9WXf7fgrJYHiHltpNeJsfjRhjeMnxqh47tMvBX2oX8/SerD7YX7PTJ9cQPJ0ZR4Qbro2jfdKvxzLKWkqIX7HidS3hXdRRDLKkTQW/v8jA4x4gYh/JUOUl1sZMgq7dyWCB4mRfl4xCHHz4VDQOnQhlyEWnR3RldiwRCeVzsLn8ipG3Mat8JC8A9BCMXoNbcAHREFrF3hWpGN4vMzk/kRw7N8AUDPznlrh2unf3sjJZyFjH6bZ8FHj2Akih7nYTqYNz0i2yPJbHE3OoYc+gVITz2w3bYOJT85MCfCLNPvq9xxhd4lxb1J1q/r89LbUex5xv8s8MZ+iPQ9iO5i/zdAVel6v408zj0jXkoW6GE8AHySIv7AoJDLhaNeqIPl7PZ13IkSfWJGB1eWQ8CQQ4fDlh95/BHNxwQbGYJZSvhjdl8NMsQ+XBXi0dhVk7k3js42pfMKWUZPfv9WP5NolUz5erAKqUcygyNXNfSI6UwzeRwHDv2So8GxkDmo/EO+t+qnj/BbTpYK8O+LaZ5PsWMYW4Sz0aVzHBhhBASQc2RaOstcwQE6amS2Mcaey7pRwUaCOX+u4csuTxHdEtOII4gApJupFMyLEVUJwQWq6RgSAtnYFvtGAiXMFH2OP3tPCdmycvWbqUvL0SFUeJWpF8lHFau7YFydxZrEcxZ2OPOrTsO6cX/Is4SFkJ0Vfe6Yrlh50dLzsBPhL40/Qilziug91Tc0v0DiLnq+v4xSprXOLVfKnDmahAZsjgFzy9nrsKjpWermdMxxc0IIO46jW5DzaCssTBoE9THDYKsl8vEWDuyE9Ril2rsFOozb+/uwXhPyauo9zgK+TCz6j4RJovz7WsI7zAsfuZwC7L7snXJ09t4NuPP8iPWb8HaT7JTF0ZY/F3aZSJIubnk2xc/Dy8HlZYegFywve/WUFt5scM5SvkQRffFuWp9ERGmz00HemrfeABvLof21hgk6jnaICue0Kx5T3TFDXAVA7EWD1poPb8AiM7s2EmGvTRRJh4rYluNRY0qxFSXOi+w5s2CfxAfNPorMSnQTqBGs+eQjBaDrwfrqg1Eu5M/eXsmNn3y3pUUcKe+bAljV27YZXRlFfwfnfn4I/VLKIXxelHaWn5OU2Runnv6TWMgmuQVqyiFoQJ797wg2Q/4cWdT+VX0uHlljmozyTLXjD5cAt72x2xfD+KH56mOy+tp0BEhhdziKPCQBkzQjCTEdIqO+f5Rh9ePW5XFPhjI+cBPrF8Rus8hA+1shRFteUsbOcHcgOJL7GvG6LxszED/v6CdvPCJ/hVejb7hN56NfOoT+uSIPv3G3b3PqJFte0nH85SfQyHo5jFCmj0U9qeeyKE2up8ZQb839EJ0hYiuawvDf7NP0yKzvwaCcFMbXaYsJCb+NJOOReC47yyVZJJxDLkFcXVN2eH8cNQKHS04ceVYGoG1En+fFztuR+ziktvHa88cD5wkRwjo6QmVzF1qQjrjNYZmzKy65KJtqjlJeXjqEfmGyqCZ+TPTqfWamBSkkjemoxPkVAWYnbNW34ZDsHR99kmPBfeKRziCnC+zNkTuE/BEU7DnhgMvAL1mrus8QEC4Xh3Y27sGhUeDxgEPjXASa3a957goLDjksPiblz95/YevFvnkgj74KRMLYEIpNFKax2YvEpuHvHNLrgwWCXZhEdJGn9Cbchdy+H/atXv55e5sk/BL9Ft5rQdZ/H43qCZXmErGGFUIvKf2xDD8svjmgdf/Fs5U/WytiKUmmvuexlfjRJSaJEAl6uTTB8TQnAP7Z9QwBOVvXH8v4V4j/ZbNtSsDvK2c4cfBb+tkyF20mwWcFeWxIzKGdXs7Z67FGmAhAt+00B3MHkD6yL+QS/q79+kY4Z4oQ+fg9PujEejrPjGHAoY/XfJjt4e0L7x8XNjJxqSHblreM5FPlUN8+rxVCJ9JTJbwX/QCgPA9no91BjpDDYlliNvmllAVrCn1fBBg/66mMZerIeQBCmgl/MI479untimgKk88pPHaHUPSPKy9gV4DH8QwehaXbI8T5rxOfhleHc397UAn7jm0bScdGMIJb30hQ+i1UZi8QXwHmE5BZW5F8twurXxhnErpvkHhBco5AEiGfd7gfvGWgp+qTesk8sHS47RHbFvo78/GOtvshA3oPnbHeLta96i3jDkjrfRnHVSxHR9pFHoof4y0sx0163iQLhFUVWZ1REo6DIupE7sq4F84VD73Wktd5kF+BvWA8sKs1dG6xl8Miq5n94/9IOL4My5OlP89nML37XCBmr7nb1LHDSqd1fN7o5HYXNShGBBebLeB80MpcEntf/Chivktyx6zw2VgiH7oBaLMCQNRL+Fhm6ssFXruHY9LHSG+yi9qIoLBdccYuMt+Ci/1lSUHHY8XKcRb3gO0T/oGralGo9fcZnTJ9/RWlzIl4hOa9QOgDMWcWubTxZdGP1CKlOCUT1/V1jxP2rbAwCOspI7PfgwIjimiQEA5ALdY4k91ydgBuNlAyDh0gYPixjV3/8zt9uhEhUz/kdNL+ZLtNn1kw4letODT0JmJMgyn5eGokGWJblPeIrQvlJohHY3bM7MDkHoAn+l4TN1RFSZylYO89bkRWD35n5lcM7/MkSnK8OfSxk0WBOYfkw0enz8sJ791Hhejvt2jnR5f+Bp0ngXMkQ2xypxc6Kz3H9ZFm5EEizjMxlqNEQpjY4bxaoVeA/9PvAA920Q8QGg4BA/Qnj0r9xngUGWevcfHIwkfKCR/N4iPi9N4ePnRQuNHFpWf8HwAPamN1xTQKhz+rZTgTqfSI6VA4fuQMcN1edn1VENVHj1bmcDzc98vPm0NnW5z3DQQNwFlQAsFQeETkC4Bv4YNavpC+MeSoD9p1TvXiB5QfQhKEjllNcBOxp8LtuWH5F0cSCpLGkuuLnpEytKOQ18VODosEfsOYjDslIp18531utDsNmB9aIuLQZgchMj5rb+FrrW1sSdhXTF0Y6kmAQWaEcc18z4uAMYd8lcevcLDkb9ByNy44v5/zBPTG265+ADtA8thr79ywOTg3eJqjsRfmF5vW0vykMZbH1xxrhA5sjJ9MdFMxJGROmqMKs3iXzs2MIpn3fX8vb0amsgmI3wt3rKWM2zoHuvQ9zGF1EfvCgYoy17heH2wUHHoo7LV+64nojU32MhdcwEb/yCIO6F3vK5XArHT/IQi/R0Tk2ZAwnBwWR/1OT2HNMC+RRWhiSGZ3O1V+pyMQuZdp2h2KFJnd8RmX13zZ76RqP8HqbBanbf3ZORS1esHUux297HFiuvXZIaHjIhyZRfxcIoilmItDj/g8j3yLysuxRugXL0u6hVxv/aGqi9jfo6Cf6VxS6LeBecIRJ/vZSXm4Cl3EYLgI9n96zr6DWvBjZDyXPFbB4Iujq5azWQ8DL0eEZWgVyaAUXKivCtLYGULA+XwFecQ3KB7uuCkYceTp/T1YG4DXEx/wkjhmw3Qdr4Yy6G9jP+yu+eFooTdUZX5xAT1LSH7QsTfCETrcOdYZF9ETDeYI7bjjYzpiNOb1vmhbfs7Dg+v5t1wefLeR9PxLi9BHxksHin0V/hOy9oQW9+uhXzJrEFpK/0bk7yU95WW4+nGV5SZWOO0FA6/I0p4rQZBHzOh83+YzZT4eLWP7e0ByXo980JfmozoOAbCByNan6l2vFnnt6GBdEpzHE9Pfau5jEl1tOMALPTQeFYXPS4VoZ/3JbjdYe8oMQX6WkwVNSV8fFq21G9trl7IRr3WwFhF6hNA7MRl7MHi4dkSiEF6XlMOM8fNzyMvx7HamEhV7zgtlSTqsn5h+v2HXmY+idDIsU+4PjdtuakSxLsWfdHaGTqOlboieurgGLQFp9+89qti+Bhi3HQtBOObivBwe3by/MZmhIQRfKIJEwdKkq1nin3HtcLQW7iX2TdOgaVooRXrWSwr3Hm7iHLrPy8GpovHhKqUwmzU4OKgxrWdoW8XifPXTJF8JEAZR267DrGtdeiJeUg6u9DHvNQjZH0fEriO0TYdm1qFrlQmXEO46DdBCN9hCousE2q5DXTeoZw3atgVQobCxKGRnDuHuI9LK1Ik3WdzAaXRqmhb1bIbZrEbX6fc42vev+DHU8HU7WmRsIy7LrGqJY4j6E7LvJu3xRGjoRlebRlfXLRTpBymFNG+QBdwKTy6cyTjDUFeSRjAJRUA9a7Gzd4C9/QPTGOwT1QFDymzeIg3qKaVQ1zPsH9Som1bnHvV3V6YQkR6h6EFCdxjLgZV5F/n+/gHqaQ2llDH4pKkPfa1LD2A6m2Fv/wAH0ynatgOgOXXQt62xkWceQX3r9mzeugugrmfY2dvD3oGtI/zo73M8rMiYAQc+WCvRw3EWd/50cCywwQjOQk+4pUFEKfRD6TqF/f0pnj7fwbPtHdSzBkVRoJCS7Z4UcunkHSGAQVcARA6x6qbFs+09PH7yDNvbu+hUh0ICEMTe5a1AilBIgUJKdKrD7v4+Hj/ZxtPnO6gbg1g2VoJg/N1hvEfI/PU+Gcp6bwRQmgayf3CAJ0+f4+mz59jb30enOshSNy7P33X9VGUJAYGD6QxPn+/g6bPn2N070K99FtLp5GcWpV+xbm0N1sD1rv+6xxSFhCwkmrbF02fPcf/hEzzf2UOrOsgCkIXOQEVrItP2MZ+ixZZU2Af9exOWF53LsetuUgqUhUas3d193H/4GPcePMFBXWM4LDEeDwEAXdeh67rM5I8X2zC7rgMADKoKVVVh1rR4/PQ57t5/hGfPtwEiDCptH+sHqxxvlFI/YCLC7u4+7t5/iHv3HmFv7wBCCAwGFcqyAJHm4/P00XorNE0DABgPBxiPhiAiPHn2HHe+e4AHj57g4GAKgFCW2nthCYJ9r3lVlqjKEnU9w8PHz/DdvUd48mwbShGKskRZ6jdeK6Wguvn6KEXo2g5t10FKieFwACkl6rrGvQePcPvOPTx7tg0iQlkWkIV01x1Hkb1D4yGMCr5b/LI9k/sH9HEzxEuPQLu7+/j2u/v45uYtPHz8BAAwHFaQUugG1LauYgkhbydoS71TnWmYAlVZoCOFx0+3cfPbu/j2u/vY3tmDlALDwUD7q5V+g63l0UIIFOZ94/vTA9y5ex/Xr9/GnTsPUE9bFIVAVRUACMqURYZOWJ24v7nrtF1QSoHxeARZSGzv7OD6zTv48votPHj4BE3ToSwkCqkj/uwIpjqCUkBZVhgOh+g6wqPHz/DNje9w4/ZdPN/ZAwCURQkphTF8O6YPi+yDRuauU2jbDqpTKAuJQVWiaxXuP3iCr6/fxs1bd7C9vQMhJKpBhUIWrm4IzHbhtsqS6MpbTBKLvXwG7qtlV8dICBASZVmiKArMZg3uP3iEL768jq+u38bTnX0UZYFTpzawsTZGIQTs5iwuFLNT+mMWmxZSYG0ywomNNZSDCts7e/jy+i189q8buHf/Mdq2w6AqI4T2ogytGAwqAMCTJ8/wr69u4NPPv8bd+48AElibjDGZjDBgDbtTdgRRLLhHv85tOCixeWId6xsTTGcz3Lj1Hf752Vf4+vptbO/soSgKVFUFIaQ1vz3iKoWiKDAaDlCWJXb39vHNjW/x6Rdf49a3dzFrWpRlgbXJGMNBpXdAUwRl6kQZekGK9CinFIpCYm0yxomNdciyxKMnz/H5v27gsy+u4969R5jNWgyqCoNS1wGZ0es4SulQknkwLPdzcRNOBPtfpyX3N8Rbm5+fl095OTOqAdhhTEAUEmVVQs0Unj3bxr++uonzZ0/jzOlT+PUv38b6ZIKqLLC9vYfOPGRnZVv8N8S9KEpMJiOUgwH29vbxr69v4j//+k988ulXePpsB1VRYlhp1HeUQXg7XtMVgdFoAKW0kfrV9dvY/Msn2NhYw9raCGfPnNTUQSkcTGu0xset7EMn4fbYKAuJ0aDEZG2EVinc/PYu/vzxp/j475/jzncP0TQdJpM1lJV2QOmOqae5Le0oRImyqjAaj3Cwv4c7d+/hb//4HOfPnMTG+gRvXbuEsqowhIAyrkkF69oTrvPb+x0NKzNaFHi+s4dP/vUN/vSXT/D5F9exvb2LQkoMhxWKQoJU5/h8aGrxp9nvoE7mCiiTMjFgg5bln3F0DjjGK1bKsgBQYTqr8eDhY3z8jy+wNplAEOGDd65gY32MtbWJG6oE65AAWKxDgbIssb2zj8+/uoH//R//wJ8//hR37j4EEbA2HqEqC5AywUKIO5mCkAJlUZphvsPT7V18+sXXWJuMMB4P8etfvoPTW5u645QFmrZD17UaFWFcWmZyp6o0HTioG9z+7gH+9OdP8Kc//xPfXL+D6UGNqqowHA5QSOGCliSz4jSV0tx+PBxCdS0Opgf45sa3+NP//QSj4QiFlHjt4jkMBxUKOUHbddrtKTQdIDNxYg3Y4XAAQODZ9h4++fwb/J///Dv++o8vcP/BEwhIjEYDVGWh68Pd0/GUMrVhIuh0gRCpNyz8SqzfsFiNyApOKyLOQXfZopAQskKnFA7qGb6+fhuq7XCwd4CdZ7t4790rOL21aYxECkHBeheEwGzW4tHTZ/ji61v4X3/6K/7Pf3yML7++jbpuMBqOMRwOIKCNTO6u5TuMEkk31A+HQ+wfKNy7/wT/+Zd/ous6bG/v4tcfvoPXbSMaFmhb7amxI5yfsRPY3tvDjW/v488ff47//ae/4dPPvsLTZ7soS91pysK8/dXQH9tpLbx1bQcqgLIoMB6N0KkOT57t4uN/fImuJTRth9/++n1cvnQB65MxirJAAd8lQIAihUJq26DtCA8ePsGnX1zH//sfH+M//vwP3Lx5F7NZg/F4hMFgAAGBjpRfTRgtcnBNxh7uIcPuEWXOx3RcZFtLxvkM3/qOJUJrrilcAxJNg729A3z9zS3U0xl2tvfw4NETvHntEs6d28JkPNRDonFXKSI0rcK0bvDoyXNcv3UXf/vkX/jPv3yCb27cxsFBjfFojPF4aIynDsoYjnmzgtApBSm08UhEmB4c4M79R2j/8k/s7u7j6bNtvPfOVZw/u4W19QlkoYOHVKcMp9b67O1Pcef+Q3zy2Tf4y8ef419f3sSzZzsaccdDVFUFwC53ItdwFNOMlEIHoJACVVVhbbyGnY7w+Ok2/vHZV1AC2N7Zx/vvXsPrF89iY2OC4ahCVZQG7WGMZWBaz/DwyTa++PIm/vK3z/HXv3+O27e/Q13PMBwOMBwOjRu1M+7G44vOACB+8+//0zR5bqZ6+5MFOzCUsQnDbpbeLnkObvJMZ/RYLyNv8QoB408VaFuF6XSKdjZDVRTYOnUSly9dxNWrr+PyGxdx/uwWNk+uYVhVAAFN12HvoMbjJzu4/e09fPnNbXxz81vcv/8Qs6bBYFBhMh6jLArnh9WNR5r3CIZ72+k70f5oKXQHmDU19vYPACJsrE1w6fULePPy67jyxgWcP38a6+sTDKoSShFmsxkOplM8eb6LB4+e4ta393Hj5nf47rsH2Ns/QCH1sD4eVZCQbA9oPZnk/cnCTLRoe6GQxo1GwLSucTCdoutabGys4bXz5/DmtUu4evk1XLhwGlsnT2AyGqEsS0AItG2D/ekUDx89xY3b9/D5lzfwzfVv8fDhE3RNg+FggNFgAFmUzk+tRwlynSJsDiJoF9TTZvzxtA3F+3Ekq7+Np0YXZf3/YYbHtkGDAEiCFIUe7pTCbFZjOq3RdQqj4RBbWydx8fwZnDt3GidPrmM4GABEmLUd9vYP8OjxNu7ee4h79x9hZ2cPUhDW1kYYjUYoykKjZ6ecXi543v3lDVrrKoXQxhEUpnWNvb0p6rpGWZbYOrGBCxdO4+zZLZw4sYbhoAIpQj2bYW9/iqfbO3j46CkePXqGnZ09qE5hOBhoZB4U2iPRaU+ENXKl6G/QAMxkk+a3Tddgb/8AdT1DIQucOrmJ8+e3cP6cadCTsR4BhEDTNNje3cWDh49x5+4D3L33EDs7+ygATEZDjEcGmd0CBEs12CM+jg36I9OgY6PK8qK+xpcqk5RtKOghGzQ5xgjARo9p5Gy7DrOmQT2doW1aiKLAeDTEeDLGaFShkJpBtV1nYjWm2N+fom0aFFJgMtaNpyhK48HQQ7tWSbKGbBsQ19frX5iIOEWaRuzv60YtiDAYVRiNhppLFxKkgLZrTVxEjYO6RjtrIYXEaDDAaDRENSghJNg+draDQesEu5LbN2w/G6oN30JqF1/d6Puu6wYQ2kU4mYwxGg4xGFQoyhIKQNu0mE4PsLu/h4O9AzRNo0eKwUC7BAtpvCo2tltTqMCTJMIGCHY+euzMiRb7JvjTtueML4Pi48FP32bYsWPJoblotFKQ0L7ZsqowHAxR1zqm4mA6w95BHVSKD8dUKKTEZDzEaFRhOKh0Q+w0J1aUOBOZ5G15IoWOBCRpjj8ZFajKEtO6wnRaYzZrsH9Qw29eDleOkJr32kajh3S9h572MTufiL2VhUIAOjdtXWA0GGmPTDXDdFajaVo8fbqt78bAqwJBtcrYDi1KKTAx+pSV5tkdmw7XBvZiXY6DlPwdG4CHfeOrMMcWix9tol4W1wTFP5lD06K4JUGsdyszgyeF1FOwcoRyoNA0LdqmQ9u1JoRZmCAkgaIQKIsCg7JAaaZs2075Yd0NnwxpyNaCMNrpRA6njXJu6ldIlIXEeDREWUjUMz0l3bat9kMrQgEdVFRWElVZoCoKzd8FQKqDMt6UcP8NPUTq/TQyxhgBwgRC67WHelJJCj39OxxWkIXUEYttq113nTLT59r7pGcjBxhUBQaV1sl2kBA3Y6oZPsxAu/j5Jo2nv03FeB9T2ySvTCbHHqGtKKX0Rn9SI9GgKjEYSHRDM3GgzBSv45oCstCPQkJ7Btqu1Q9LpdTHi0Vm7ldI0xC0q08IHXMxKAv9t6owGg7QtZ1rPACZmBBtyOlRmdykkEZPnfNRgZAUoKBAQgdUlabTqGEFZWYErc1gp+GlhKsnKWzci3EXWnA5bpPJC2RBg+6p3h4qnfcQLsgLiLoeIQYEP1zCxB90JhxUpy3MxIc1XOB8yLojtGaqVymz27ywIxAvKIrgdkaA0yC9H+H1UXYjFiKUUqCoCiiSfhW1maa3AUZuyt4N556rh6v/vOeViGuhKZVWwmyMY/Ux7zPk7xMvCwkUAqQKuD31rM2iCC06H9Un7Bhh6nxhL+Mc1yJwhl/z3zzTKP94hE5KyrQ3+/2YIfRicuM2Q1cdhNSzgX4TcpbOxC3o4BzlXvjOm8rSKok5v61xaXT3IZoptmkGYhuy92QgasCLdbI0TZnGHI4mNvTVGZaFMBvx6AUCBAmhdKCTjkg0ngxxyLo5hpK+p9B1KNa4eruo7cGZLpMyIv0rgXHG1fKXROkj9IAeIq394vDBNnwbXWbiM/QAQEF+scYmhyBtsL815e5Oz+4pF9ttIsgU+UQuBoKhseDlhxGIsU7ae2B7FP/rNNbXGGS27k/VETrz3e6PAtuQ4f3+ECJ67D3oym7HHXdJwlFvsWTG9bghUJRaRL+ZHDOEXlICJDaNmuw0sUkS3yl/9i9Q7LDtXsVmlBKRTnwLhiOUkrk2z/n1mkX/ujjeoAmso4q4K72cUvpuFuKTrzLB+mcfWRaM0tmnh/BqSpFOkL80SB3tnCNieAQHAnsN53H8Tkx2gb/SpHWtLfcoeXoknSHXX4TTy14kA17pNBRRBcaUZo4EtMro73y9plNbKpM+WZH7ExbrNg+EszeWkghJzDp7dji6sQT9ka9U+HY3t8uZa19OhM5IcrNsyP1J9GEdzDcW/HT6mL8eke2Bn0CZFyhlvgvme0K2DgJHwLzaia4Wubqknl+mh7JOnWrYVzb1nutniMxG7/WrU3Btml9PuRFvj28mN15mMghSU0wsc8OJDm43fYqtDrFozXtdD2iKRb2ADR8UfaE0Sa+6fTefrZvo2lcGoVPpb8greXUlv7cdR5Fcu0h6EM2DlLmXxllzc8eN0Jx32y/G2vdcOkZ3awSZ5FllOMPt04vPnYJx8fBaYXUgdlXEVZOZruzgyFCXlp1y1jdJzCgMvBWZbx6tI11y10W33s9X+GynGz8Wap94t2IoXoYemTSvMEL/HKWPsPx8RqqSKGz+wq5QYbZlzLNyBqoV18l6elm4E1xk7Vt0SxDZJrHel8TUT8oPuSqxn4shj2eZeHhECFfMoROWj/hee/hjrNJCEm1GpmwbnWdH5A+J6LksyimU2F1CyZxEVF3R1ZxzZyo9k87l3VM/L9dE/UpWskBKj8z2UISa/NgihMn1Qud/zvHV1NU2L/95fsiEJ1run1m1nl4Tn83hU55D96XOZjw3YXSyB86t7znMOL4k3lkwjTlOQC/jGImuSOsrA5zpPUZeInY02f8wLnzeYNpz6QqhV/JKCTMKc4bED2FMLOKsGRdEcsmSLpQ4XwYtDj1YVhHDTq5fptRlwGRRDtx70Btac5Scs0R7wWiblIw5zeAwWoU4TxFyz1XBFcOMufic+b1C6JW8UlLmqVrEoHo6IqfdsSXv4z4MR89xK+vYEJgP1BEPz51LNOfOzcDTIgK9c6IBIMKOmO730b/QLRNemvPfM+9OpF2gYi6ORkRKeHrfw7+5Tu6Bhc5fyt107E+PM469NMH9RM9uTnB1ErNxGA+MSbJC6JW8UlIm3c/+iH3AQNI10p6Swmzk5g49CQTuCM1kmHoU+svuSyCiY/1OzNwlsfSd6l1dkS9B/1rKRDm8HePeGDA3vxgxU7a+jNt8XtZal/iLTZLm0ufFoqzO+btbIfRKXilhXo45XtnYRTonwz6QPZwsa4n7RIkfevlSlnITHw6tjuCw79FpKRf2EUpbHo+zifMJ+oEzU8qchL2DhhldhS8snudYIfRKXinJR9vxKR/XG5CsOsi+Q9tInz819J8I1ql5DLL5y+l9oJOxnXNBF9l7QeCsif2zsU+UeHB+FiXAkCG+m34VQj/DfMXnjJdponh7omR3qnTEc3Vs05BPS+zKnP7urCuWeXPsMcfje7izex5xGTxxqCS3DPoe9wqhV/JKifNDK4a2ArGPM893cu7OIGaWnRcZy9su5Y+8tRmk1i4Xt7Yw647IE71Qxz7eFuvmx4w4xiXxKTOIo+yJVM3M8sYejeZpHntv+KE+Jzl3KkX3HPn4nTuZjYyxqglyZ0Zsvjqf/xXkNRBsRX6Qf/y4WXF8ca8+plOtEHolr5SUrq8yvrrI/5yeWMod0Z9Fz+XzrPQ4zjaOPc4XdAid7JdF3NxrtLCc+Ww5P7LYdSWCbWsczx30lZgtLxndctZNkjir6WE2PvC7MDGkJn28d1V34iPvV0asvBwreRWl5GAUiMj9mM9BAd9T0s7L8uAWriNrKd/KZJ/J2/R4CstdBp3mccKYjvanXQKlMsgaWOwZ74O7goIKAoflNDS7X8s+VfpmCvl4l/L5uP4y6XoHqrAdhGlj2O1TPjUX7G2sEHolr5S4nZMClNBHPFeat4jQXEGIrHeHHvoa/f6koABYAh0DTIzUglvPiWMj7Oa5qL4Yc2LPRToA9KPuwtFjrvh6NMxYH2V2RN5/H+uTH2Hiq7hqgv0N/bn9BVPk+Yrzde9bZ/r0OLmQ3XXLHI93OWX7LSXX9I5m5vsKoVfySkm6jQGlXxftDUHsYyXHQfsdA4fwkizDzXJ6ZIpJ9zDuz3WRHvG7YoL5trmbq4dfI1Mg2Bc7vU5kf7pyGSj2Ojd6PVXMjkje7hB7P/hI25dfjqtzD0vMyMNv7ghPGjQq/WWF0Ct5paRMeUrO5xd3/fx5YbAgtZP170WeYpZhUEzOVveIs4hPekm5eU/+InOL/RAH5rbQpy3K9k11BUZDNKIkwyJlfor8kBddm9vrou9NZpS4TATi1SyJ9yEYfZOo5SXEXqkz67Vd4iqPUZqdWyH0Sl4p+f8BvhI71HNUaB4AAAAASUVORK5CYII="><title>DataLogger</title><style>
:root{--navy:#253044;--orange:#ffb333;--bg:#f2f5fa;--ink:#263348;--muted:#647087;--green:#31a268;--red:#dc393e;--white:#fff}*{box-sizing:border-box}body{margin:0;background:var(--bg);color:var(--ink);font-family:Arial,Helvetica,sans-serif}button,select{font:inherit}button{cursor:pointer;border:0}button:focus-visible,a:focus-visible,select:focus-visible{outline:3px solid #398bdc;outline-offset:2px}.app{max-width:540px;margin:auto;min-height:100dvh;background:var(--bg)}.top{background:var(--navy);color:white;padding:calc(env(safe-area-inset-top) + 18px) 18px 18px;display:flex;justify-content:space-between;align-items:center;min-height:75px}.brand{font-size:23px;font-weight:800}.brand span{color:var(--orange)}.top button{background:transparent;color:white;font-size:27px;padding:3px 9px}.page{display:none;padding-bottom:calc(115px + env(safe-area-inset-bottom))}.page.current{display:block}.hero{height:175px;position:relative;overflow:hidden;background:linear-gradient(130deg,#253044 20%,#657a90 65%,#f3d2b6);color:white;padding:23px 18px}.hero:after{content:' ';position:absolute;right:-10%;bottom:20px;width:80%;height:80px;background:#384a5c;clip-path:polygon(0 100%,25% 40%,39% 70%,55% 10%,72% 60%,85% 30%,100% 100%);opacity:.85}.hero h1{margin:0;font-size:25px;position:relative;z-index:1}.hero p{position:relative;z-index:1}.system{position:absolute;bottom:0;left:14px;right:14px;background:white;color:var(--ink);border-radius:13px 13px 0 0;display:flex;justify-content:space-between;gap:8px;padding:12px;font-size:12px;z-index:2}.dot{display:inline-block;width:9px;height:9px;border-radius:50%;background:var(--green);margin-right:7px}.content{background:white;padding:14px;border-radius:13px 13px 0 0}.homeactions{display:grid;grid-template-columns:1fr 1fr;gap:10px}.action{border-radius:13px;padding:17px 8px;min-height:132px;display:flex;flex-direction:column;align-items:center;justify-content:center;gap:10px;font-size:15px;box-shadow:0 3px 9px #1b2d4120}.action small{font-size:11px}.action.start{background:var(--orange);color:var(--ink)}.action.data{background:var(--navy);color:white}.action .bigicon{width:38px;height:38px;display:flex;align-items:center;justify-content:center}
.action .bigicon svg{width:34px;height:34px;display:block}
.playIconSvg{width:31px;height:31px;display:block}
.nav .playIconSvg{width:30px;height:30px}
.sectiontitle{display:flex;justify-content:space-between;align-items:end;margin:22px 2px 14px}.sectiontitle h2{margin:0;font-size:18px;letter-spacing:-.2px}.live{font-size:13px;color:var(--muted);display:flex;align-items:center;gap:6px}.sensors{display:grid;grid-template-columns:1fr 1fr;gap:14px}.sensor{position:relative;border:1px solid #e4e9f1;border-radius:18px;padding:0;background:white;box-shadow:0 8px 20px #27374b10;display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:146px;overflow:hidden}.sensor.compact{min-height:132px}.sensoricon{display:flex;align-items:center;justify-content:center;padding:18px}.sensoricon .iconwrap{width:64px;height:64px;flex:0 0 64px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}.sensorcontent{display:flex;flex-direction:column;justify-content:center;padding:18px 18px 18px 8px}.symbol{font-size:26px;display:flex;align-items:center;justify-content:center;line-height:1}.symbol svg{width:30px;height:30px;display:block}.measuregrid .tile .symbol svg{width:29px;height:29px}.label{font-size:12px;color:#627188;margin-bottom:6px}.value{font-size:18px;font-weight:800;line-height:1.12;margin:0;color:var(--ink)}.sensor.emphasis .value{font-size:20px}.sensor.compact .value{font-size:16px}.sub{color:var(--muted);font-size:12px;line-height:1.35;margin-top:10px}.sd{width:100%;margin-top:14px;background:white;border:1px solid #e4e9f1;border-radius:18px;text-align:left;padding:0;display:grid;grid-template-columns:22% 1fr auto;align-items:center;box-shadow:0 8px 20px #27374b10;overflow:hidden}.sd .sensoricon{padding:18px 12px}.sd .sensoricon .iconwrap{width:56px;height:56px}.sd .sensorcontent{padding:18px 8px 18px 0}.sd .arrow{margin-right:18px;font-size:30px;color:#738199}.sd .value{font-size:16px;margin-top:2px}.sd .label{margin-bottom:2px}@media (max-width:380px){.sensors{grid-template-columns:1fr}.sensor{min-height:118px}.sd{grid-template-columns:26% 1fr auto}}.nav{position:fixed;bottom:0;left:50%;transform:translateX(-50%);width:min(100%,540px);display:grid;grid-template-columns:repeat(4,1fr);background:var(--navy);border-radius:16px 16px 0 0;padding:10px 0 calc(24px + env(safe-area-inset-bottom));z-index:10}.nav button{color:#bac3d1;background:none;display:flex;align-items:center;justify-content:center;gap:0;flex-direction:column;font-size:0;min-height:56px;padding:6px 0}.nav button span{font-size:31px;line-height:1;display:block}.nav button .homeNavIcon{font-size:36px}.nav button .chartNavIcon{display:flex;align-items:flex-end;justify-content:center;gap:4px;height:30px;width:34px}.nav button .chartNavIcon i{display:block;width:6px;border-radius:6px;background:currentColor;opacity:.98}.nav button .chartNavIcon i:nth-child(1){height:15px}.nav button .chartNavIcon i:nth-child(2){height:25px}.nav button .chartNavIcon i:nth-child(3){height:20px}.nav button.selected{color:var(--orange)}.sheet{background:white;border-radius:17px;padding:18px 14px;margin:0 3px;box-shadow:0 2px 12px #22314a15}.heading{display:flex;justify-content:space-between;align-items:start;gap:9px}.heading h1{font-size:19px;margin:3px 0 5px}.heading p{font-size:13px;color:var(--muted);margin:0}.pill{border-radius:20px;background:#d8f5e3;color:#238651;padding:7px 13px;font-size:13px}.clock{display:flex;flex-direction:column;align-items:center;gap:4px;margin:16px 0 21px;text-align:center}.clock .metric{border:0;background:transparent;box-shadow:none;padding:0;min-width:0;width:100%;text-align:center}.clock .metric:first-child{padding:7px 0 2px}.clock .metric:first-child .metric-label{font-size:13px;margin-bottom:7px}.clock .metric:first-child strong{display:block;font-size:clamp(39px,10vw,52px);line-height:1.05;letter-spacing:-1.5px;font-weight:800;font-variant-numeric:tabular-nums}.clock .metric:last-child{display:flex;justify-content:center;align-items:baseline;gap:6px;padding:2px 0 0}.clock .metric:last-child .metric-label{font-size:13px;margin:0;color:var(--muted)}.clock .metric #count{font-size:16px;font-weight:800;color:var(--ink);font-variant-numeric:tabular-nums}.clock strong{overflow-wrap:anywhere}
.measuregrid{display:grid;grid-template-columns:1fr 1fr;gap:14px;margin-top:14px}.measuregrid .tile{position:relative;border:1px solid #e4e9f1;border-radius:18px;padding:0;background:white;box-shadow:0 8px 20px #27374b10;display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:146px;overflow:hidden}.measuregrid .tileicon{display:flex;align-items:center;justify-content:center;padding:18px}.measuregrid .tileicon .iconwrap{width:64px;height:64px;flex:0 0 64px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}.measuregrid .tilecontent{display:flex;flex-direction:column;justify-content:center;padding:18px 18px 18px 8px}.measuregrid .tile .label{font-size:12px;color:#627188;margin-bottom:6px}.measuregrid .tile .value{font-size:20px;font-weight:800;line-height:1.12;margin:0;color:var(--ink)}.measuregrid .tile .sub{color:var(--muted);font-size:12px;line-height:1.35;margin-top:10px}.measuregrid .tile .symbol{font-size:26px;display:flex;align-items:center;justify-content:center;line-height:1}.measuregrid .tile .symbol svg{width:30px;height:30px;display:block}.settingrow{border-radius:12px;background:#f5f7fa;display:flex;justify-content:space-between;align-items:center;padding:12px;margin-top:10px;gap:8px}.settingrow small{display:block;color:var(--muted);margin-top:4px}.settingrow button{border-radius:9px;background:#e5eaf0;padding:10px;font-size:13px}.measureactions{display:grid;grid-template-columns:1fr 1fr;gap:10px;margin:12px 0 8px}.measureactions button,.stop,.startbtn{border-radius:11px;padding:15px 8px;font-weight:700}.continue{background:var(--navy);color:white}.pause{background:var(--orange);color:var(--ink)}.stop{background:var(--red);color:white;width:100%}.startbtn{background:var(--orange);width:100%}.hidden{display:none!important}.location{display:grid;grid-template-columns:1fr 45%;border-radius:14px;overflow:hidden;border:1px solid #e1e8ef;margin-top:13px;min-height:128px}.map{background:linear-gradient(140deg,#dcf7e8 0%,#edf6eb 45%,#bee4ef 46%,#d7eeff 70%,#e5f5e8 71%);position:relative;overflow:hidden}.map:before{content:'';position:absolute;top:44%;left:46%;width:19px;height:19px;border-radius:50%;background:#267ddb;border:3px solid white;box-shadow:0 2px 6px #173e6b44;z-index:2;transform:translate(-50%,-50%);animation:mapDot 2s ease-in-out infinite}.map:after{content:'';position:absolute;top:44%;left:46%;width:24px;height:24px;border-radius:50%;background:#1e5fa84a;z-index:1;transform:translate(-50%,-50%) scale(.65);animation:mapPulse 2s ease-out infinite}@keyframes mapDot{0%,100%{transform:translate(-50%,-50%) scale(1)}50%{transform:translate(-50%,-50%) scale(1.12)}}@keyframes mapPulse{0%{transform:translate(-50%,-50%) scale(.65);opacity:.78}70%{opacity:.24}100%{transform:translate(-50%,-50%) scale(3.2);opacity:0}}.manualviewer{position:fixed;inset:0;z-index:120;background:var(--surface);display:none;flex-direction:column}.manualviewer.open{display:flex}.manualviewerbar{height:58px;flex:0 0 58px;display:flex;align-items:center;justify-content:space-between;gap:10px;padding:8px 12px;background:var(--navy);color:#fff;padding-top:max(8px,env(safe-area-inset-top))}.manualviewerbar strong{font-size:14px}.manualvieweractions{display:flex;gap:8px}.manualviewerbar button{min-height:38px;border-radius:10px;padding:0 12px;font-weight:800}.manualviewerpdf{background:var(--orange);color:#232323}.manualviewerclose{background:rgba(255,255,255,.12);color:#fff}.manualviewer iframe{width:100%;height:100%;border:0;background:#fff;flex:1 1 auto}
@media (prefers-reduced-motion:reduce){.map:before,.map:after{animation:none}}.locationaside{padding:13px;font-size:12px}.locationaside p{color:#438dde;font-weight:700;line-height:1.6}.locationaside small{color:var(--muted)}.meta{font-size:11px;color:var(--muted);margin-top:15px}.datawrap{padding:17px}.datatop{display:flex;align-items:flex-start;justify-content:space-between;gap:12px;margin-bottom:14px}.datatop h1{font-size:18px;margin:0 0 3px}.periodpill{background:var(--soft);border:1px solid #e4e9f1;border-radius:10px;padding:9px 12px;font-size:12px;color:var(--muted);font-weight:700;white-space:nowrap}.overviewgrid{display:grid;grid-template-columns:repeat(3,1fr);gap:10px;margin-bottom:18px}.overviewcard{background:white;border:1px solid #e4e9f1;border-radius:14px;padding:12px 11px;box-shadow:0 1px 6px #24344a0f}.overviewiconrow{display:flex;align-items:center;gap:8px;color:var(--ink);margin-bottom:7px;min-height:20px}.miniicon{width:18px;height:18px;display:inline-flex;align-items:center;justify-content:center;color:var(--navy)}.miniicon svg{width:18px;height:18px;display:block}.overviewvalue{font-size:28px;font-weight:800;line-height:1;margin-bottom:4px}.overviewlabel{font-size:12px;color:var(--muted)}.sectionhead{font-size:18px;font-weight:800;margin:0 0 12px}.filetoolbar{display:flex;gap:10px;align-items:center;margin-bottom:12px}.searchbox{flex:1;display:flex;align-items:center;gap:8px;background:var(--soft);border:1px solid #e4e9f1;border-radius:12px;padding:0 12px;height:44px;color:var(--muted)}.searchbox input{border:0;background:transparent;outline:none;width:100%;font-size:14px;color:var(--ink)}.filterbtn{height:44px;border-radius:12px;padding:0 14px;background:var(--soft);border:1px solid #e4e9f1;font-weight:700;color:var(--ink);display:flex;align-items:center;gap:8px}.sessionlist{background:white;border:1px solid #e4e9f1;border-radius:16px;overflow:hidden;box-shadow:0 1px 6px #24344a0f}.sessionrow{display:grid;grid-template-columns:40px minmax(0,1fr) auto;gap:12px;align-items:center;padding:14px 16px;border-bottom:1px solid #edf1f6}.sessionrow:last-child{border-bottom:0}.fileicon{width:38px;height:38px;border-radius:11px;background:var(--soft);display:flex;align-items:center;justify-content:center;color:var(--navy)}.fileicon svg{width:20px;height:20px;display:block}.sessiontitle{font-size:14px;font-weight:800;margin:0 0 5px;line-height:1.25}.sessionmeta,.sessionsub{font-size:12px;color:var(--muted);line-height:1.3}.sessionactions{display:flex;align-items:center;gap:6px}.sessionmenubtn{width:40px;height:40px;border-radius:12px;background:var(--surface-alt);border:1px solid var(--border);color:var(--ink);display:inline-flex;align-items:center;justify-content:center;font-size:22px;line-height:1}.sessionmenubtn:active{transform:scale(.98)}.sessionactionsheet{display:grid;gap:8px}.sessionaction{width:100%;min-height:52px;border-radius:12px;background:var(--surface-alt);color:var(--ink);display:grid;grid-template-columns:36px 1fr;align-items:center;gap:10px;padding:0 14px;text-align:left;font-weight:800}.sessionaction .saicon{width:36px;height:36px;border-radius:10px;background:var(--surface);display:flex;align-items:center;justify-content:center;border:1px solid var(--border)}.sessionaction.danger{color:#c83238}.sessionaction.danger .saicon{color:#c83238}.sessionaction small{display:block;font-size:12px;color:var(--muted);font-weight:500;margin-top:2px}.sessionmore{background:none;color:var(--muted);font-size:20px;line-height:1;padding:7px 3px}.filterbtn.active{border-color:var(--orange);background:#fff5de}.filterpanel{background:white;border:1px solid #e4e9f1;border-radius:14px;padding:12px;margin:-2px 0 12px;box-shadow:0 6px 18px #24344a12}.filterpanel[hidden]{display:none}.filterlabel{display:block;font-size:12px;font-weight:700;margin-bottom:7px}.filteroptions{display:grid;grid-template-columns:repeat(3,1fr);gap:8px}.filteroption{border:1px solid #dfe5ed;background:var(--soft);border-radius:10px;padding:10px 7px;font-size:12px;color:var(--ink);font-weight:700}.filteroption.active{border-color:var(--orange);background:#fff5de}.emptyhint{padding:14px;font-size:13px;color:var(--muted)}@media(max-width:380px){.measuregrid{grid-template-columns:1fr}.measuregrid .tile{min-height:122px}.measuregrid .tilecontent{padding-right:16px}}.settingswrap{padding:22px 18px 130px}.settingswrap>h1{font-size:28px;margin:5px 0 22px}.settingssection{margin-bottom:22px}.settingssection h2{font-size:15px;margin:0 0 9px;color:var(--muted);font-weight:800;letter-spacing:.2px}.settingscard{background:var(--surface);border:1px solid var(--border);border-radius:16px;overflow:hidden;box-shadow:0 2px 8px var(--shadow)}.settingitem{width:100%;min-height:64px;padding:12px 14px;display:grid;grid-template-columns:38px minmax(0,1fr) auto;align-items:center;gap:12px;background:transparent;color:var(--ink);text-align:left;border-bottom:1px solid var(--border)}.settingitem:last-child{border-bottom:0}.settingicon{width:38px;height:38px;border-radius:11px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;color:var(--navy);font-size:20px}.settingcopy{min-width:0}.settingtitle{display:block;font-size:14px;font-weight:800;line-height:1.25}.settingdesc{display:block;margin-top:4px;font-size:12px;color:var(--muted);white-space:nowrap;overflow:hidden;text-overflow:ellipsis}.settingright{display:flex;align-items:center;gap:8px;color:var(--muted);font-size:12px;white-space:nowrap}.chevron{font-size:20px;line-height:1}.statusok{display:inline-flex;align-items:center;gap:5px}.statusok:before{content:'';width:7px;height:7px;border-radius:50%;background:var(--green)}.themebuttons{padding:12px}.themeswitch{position:relative;display:grid;grid-template-columns:1fr 1fr;align-items:center;background:var(--navy);border:1px solid color-mix(in srgb,var(--navy) 72%,white 28%);border-radius:999px;padding:5px;min-height:62px;overflow:hidden;box-shadow:inset 0 0 0 1px rgba(255,255,255,.04)}.themeswitch::before{content:"";position:absolute;top:5px;bottom:5px;left:5px;width:calc(50% - 5px);border-radius:999px;background:var(--orange);box-shadow:0 5px 16px rgba(252,176,49,.34);transition:left .42s cubic-bezier(.22,1,.36,1),box-shadow .3s ease}.themeswitch[data-active="dark"]::before{left:50%}.themeswitch button{position:relative;z-index:1;min-height:52px;border-radius:999px;border:0;background:transparent;color:#d8deea;font-weight:800;font-size:15px;display:flex;align-items:center;justify-content:center;gap:8px;transition:color .25s ease,transform .18s ease}.themeswitch button[aria-pressed="true"]{color:#202838}.themeswitch button:active{transform:scale(.97)}.themeglyph{font-size:17px;line-height:1;transition:transform .35s cubic-bezier(.22,1,.36,1)}.themeswitch button[aria-pressed="true"] .themeglyph{transform:rotate(12deg) scale(1.12)}.walkthroughbtn{width:100%;min-height:54px;border-radius:12px;background:var(--orange);color:var(--ink);font-weight:800;font-size:15px}.guidehero{padding:2px 0 6px}.guideeyebrow{display:inline-flex;align-items:center;gap:6px;font-size:12px;font-weight:800;color:var(--orange);letter-spacing:.2px;margin-bottom:10px}.guidehero h3{font-size:24px;line-height:1.15;margin:0 0 8px}.guidehero p{font-size:14px;line-height:1.55;color:var(--muted);margin:0}.guidecard{background:var(--surface-alt);border:1px solid var(--border);border-radius:16px;padding:14px 14px 12px;margin-top:14px}.guidecard h4{margin:0 0 6px;font-size:15px}.guidecard p{margin:0;color:var(--muted);font-size:13px;line-height:1.5}.guidelist{display:grid;gap:10px;margin-top:14px}.guideitem{display:grid;grid-template-columns:36px 1fr;gap:10px;align-items:start;padding:12px;border:1px solid var(--border);border-radius:14px;background:var(--surface)}.guideitemicon{width:36px;height:36px;border-radius:12px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;font-size:18px;color:var(--navy)}.guideitem b{display:block;font-size:14px;margin-bottom:4px}.guideitem small{display:block;font-size:12px;line-height:1.45;color:var(--muted)}.guideprogress{display:flex;align-items:center;justify-content:space-between;gap:12px;margin-top:16px}.guideprogress small{font-size:12px;color:var(--muted);font-weight:700}.guidedots{display:flex;gap:6px;align-items:center}.guidedot{width:8px;height:8px;border-radius:999px;background:#d9dfeb;transition:all .22s ease}.guidedot.active{width:24px;background:var(--orange)}.guideactions{display:flex;justify-content:flex-end;gap:10px;align-items:center;margin-top:18px}.guidebtn{min-height:46px;padding:0 14px;border-radius:12px;font-weight:800}.guidebtn.secondary{background:var(--surface-alt);color:var(--ink);border:1px solid var(--border)}.guidebtn.primary{background:var(--orange);color:var(--ink)}.guidebtn.ghost{background:transparent;color:var(--muted)}.guideactionstack{display:flex;justify-content:flex-end;gap:10px}.guideinline{display:grid;gap:10px;margin-top:14px}.guidethemeinline{position:relative;display:grid;grid-template-columns:1fr 1fr;background:var(--navy);border:1px solid var(--border);border-radius:999px;padding:5px;min-height:62px;overflow:hidden;margin-top:14px}.guidethemeinline::before{content:"";position:absolute;top:5px;bottom:5px;left:5px;width:calc(50% - 5px);border-radius:999px;background:var(--orange);box-shadow:0 5px 16px rgba(252,176,49,.32);transform:translateX(0);transition:transform .38s cubic-bezier(.22,1,.36,1)}.guidethemeinline[data-active="dark"]::before{transform:translateX(100%)}.guidethemeinline button{position:relative;z-index:1;min-height:52px;border:0;border-radius:999px;background:transparent;font-weight:800;color:#d8deea;display:flex;align-items:center;justify-content:center;gap:8px}.guidethemeinline button.active{color:#202838}.guidecallout{margin-top:14px;padding:12px 14px;border-radius:14px;background:#fff8e8;border:1px solid #f3d182;color:#5d4a15;font-size:12px;line-height:1.5}.modalaction{width:100%;margin-top:12px;min-height:48px;border-radius:11px;background:var(--orange);color:var(--ink);font-weight:800}.modalinfo{display:grid;gap:10px;margin-top:10px}.modalinforow{display:flex;justify-content:space-between;gap:12px;padding:11px 0;border-bottom:1px solid var(--border);font-size:13px}.modalinforow:last-child{border-bottom:0}.modalinforow span:last-child{font-weight:800;text-align:right}
.dataviewmeta{display:flex;flex-wrap:wrap;gap:8px;margin:0 0 14px}
.dataviewchip{font-size:12px;color:var(--muted);background:var(--surface-alt);border:1px solid var(--border);border-radius:999px;padding:7px 10px}
.datatablewrap{width:100%;overflow:auto;border:1px solid var(--border);border-radius:14px;background:var(--surface);max-height:52dvh;-webkit-overflow-scrolling:touch}
.datatable{width:100%;border-collapse:separate;border-spacing:0;min-width:760px;font-size:12px;font-variant-numeric:tabular-nums}
.datatable th{position:sticky;top:0;z-index:2;background:var(--navy);color:#fff;text-align:left;padding:11px 10px;font-size:11px;letter-spacing:.15px;white-space:nowrap}
.datatable td{padding:10px;border-bottom:1px solid var(--border);white-space:nowrap;color:var(--ink)}
.datatable tbody tr:last-child td{border-bottom:0}
.datatable tbody tr:nth-child(even){background:var(--surface-alt)}
.datatable .num{text-align:right}
.datatableempty{padding:26px 18px;text-align:center;color:var(--muted);font-size:13px}
.dataviewfooter{display:flex;align-items:center;justify-content:space-between;gap:10px;margin-top:12px}
.dataviewfooter small{color:var(--muted);font-size:11px;line-height:1.35}
.dataviewfooter .modalaction{width:auto;margin:0;padding:0 16px}
@media(max-width:420px){
  .datatablewrap{max-height:48dvh;border-radius:12px}
  .datatable{font-size:11px;min-width:700px}
  .datatable th,.datatable td{padding:9px 8px}
  .dataviewfooter{align-items:flex-start;flex-direction:column}
  .dataviewfooter .modalaction{width:100%}
}
.modaloverlay{position:fixed;inset:0;z-index:30;background:#142035aa;display:none;align-items:center;justify-content:center;padding:15px}.modaloverlay.open{display:flex}.modal{background:white;border-radius:19px;padding:20px;width:min(100%,470px);max-height:88dvh;overflow:auto}.modal header{display:flex;justify-content:space-between;align-items:center}.modal h2{font-size:20px}.modal .close{background:none;font-size:23px;color:var(--ink)}.modal section{padding:14px 0;border-top:1px solid #e7ebf0}.modal section p{font-size:13px;color:var(--muted);line-height:1.5}.options{display:grid;gap:8px}.option{display:block;width:100%;border:2px solid #e2e7ef;background:white;border-radius:13px;padding:13px;text-align:left;color:var(--ink)}.option.selected{border-color:var(--orange);background:#fff5de}.option small{display:block;color:var(--muted);margin-top:5px}.hint{border-radius:10px;background:#f0f3f8;padding:11px;font-size:12px;line-height:1.5;color:#475569;margin-top:10px}.toast{position:fixed;bottom:calc(90px + env(safe-area-inset-bottom));left:50%;transform:translateX(-50%);z-index:45;background:var(--navy);color:white;border-radius:12px;padding:12px 17px;display:none;max-width:90%;text-align:center}.toast.show{display:block}

/* Meetpagina: consistente binnenmarges en uitlijning van sensortegels */
.measuregrid{gap:12px;grid-template-columns:repeat(2,minmax(0,1fr))}
.measuregrid .tile{padding:18px 16px;min-height:116px;gap:13px;align-items:center;min-width:0}
.measuregrid .tile .symbol{flex:0 0 29px;width:29px;text-align:center;font-size:25px;line-height:1}
.measuregrid .tile>div{flex:1;min-width:0}
.measuregrid .tile .label{font-size:15px;line-height:1.35;margin-bottom:7px}
.measuregrid .tile .value{font-size:20px;line-height:1.22;margin:0 0 8px;overflow-wrap:break-word}
.measuregrid .tile .sub{font-size:14px;line-height:1.35;margin:0}
@media(max-width:370px){.measuregrid{gap:9px}.measuregrid .tile{padding:15px 11px;gap:8px}.measuregrid .tile .symbol{flex-basis:23px;width:23px;font-size:22px}.measuregrid .tile .label{font-size:14px}.measuregrid .tile .value{font-size:18px}.measuregrid .tile .sub{font-size:13px}}

/* DataLogger: twee volledig werkende, opgeslagen thema's. */
:root {color-scheme:light;--bg:#E9E9E9;--ink:#232323;--muted:#526075;--navy:#343F58;--orange:#FCB031;--surface:#FFFFFF;--surface-alt:#F1F3F6;--border:#DCE2EB;--shadow:rgba(35,35,35,.09);--button-text:#FFFFFF}
:root[data-theme="dark"] {color-scheme:dark;--bg:#232323;--ink:#FFFFFF;--muted:#C0CAD8;--navy:#343F58;--orange:#FCB031;--surface:#30394B;--surface-alt:#283246;--border:#4B5870;--shadow:rgba(0,0,0,.22);--button-text:#FFFFFF}
body,.app{background:var(--bg);color:var(--ink)}
.content,.sheet,.panel,.sensor,.tile,.sd,.modal{background:var(--surface);color:var(--ink)}
.sensor,.tile,.sd,.location,.option{border-color:var(--border);box-shadow:0 2px 8px var(--shadow)}
.settingrow,.hint,.state,.option{background:var(--surface-alt);color:var(--ink)}
.settingrow button{background:var(--border);color:var(--ink)}
.label,.option small,.locationaside small,.meta,.sub,.settingrow small{color:var(--muted)}
.file,.modal section{border-color:var(--border)}
#settings .panel button[onclick="openModal('about')"]{background:var(--surface)!important;color:var(--ink);border:1px solid var(--border);border-radius:11px}
.action.start,.startbtn,.pause{background:var(--orange);color:#232323}
.action.data,.continue,.file button{background:var(--navy);color:#FFFFFF}
.stop{background:var(--red);color:#FFFFFF}
.hero{background:linear-gradient(130deg,#253044 20%,#657a90 65%,#f3d2b6);color:#FFFFFF}
.system{background:var(--surface);color:var(--ink)}
.nav,.top{background:var(--navy);color:#FFFFFF}
.nav button{color:#E9E9E9}.nav button.selected{color:var(--orange)}
:root[data-theme="dark"] .pill{background:#214C3A;color:#A5E6C0}
:root[data-theme="dark"] .locationaside p{color:#87BEFF}
:root[data-theme="dark"] .map{background:linear-gradient(140deg,#244B3C 0%,#304B42 45%,#224457 46%,#31546A 70%,#305041 71%)}
:root[data-theme="dark"] .option.selected{background:#554526;border-color:var(--orange)}
:root[data-theme="dark"] .sd .arrow{color:var(--muted)}
:root[data-theme="dark"] #badge{color:#232323}
@media(prefers-reduced-motion:reduce){*,*:before,*:after{scroll-behavior:auto!important;transition:none!important;animation:none!important}}

/* Mobile-first interval sheet */
.modal:has(#intervalChoices){width:min(100%,520px);padding:clamp(20px,5vw,30px);border-radius:24px;max-height:calc(100dvh - 32px);overflow-y:auto}
.interval-intro{color:var(--muted);line-height:1.5;margin:0 0 19px}
.interval-choices{display:grid;grid-template-columns:repeat(4,minmax(0,1fr));gap:10px;margin:16px 0 21px}
.interval-choice{background:var(--surface-alt);border:2px solid var(--border);border-radius:15px;min-height:80px;padding:10px 5px;color:var(--ink);display:flex;flex-direction:column;align-items:center;justify-content:center;gap:5px;font-weight:800;font-size:20px;transition:border-color .12s,background .12s}
.interval-choice small{font-size:12px;font-weight:500;color:var(--muted)}
.interval-choice[aria-pressed="true"]{border-color:var(--orange);background:color-mix(in srgb,var(--orange) 13%,var(--surface));box-shadow:inset 0 0 0 1px var(--orange)}
.interval-help{border-radius:12px;background:var(--surface-alt);padding:13px 15px;color:var(--muted);line-height:1.45;font-size:13px;margin-bottom:20px}
.interval-save{width:100%;min-height:56px;font-weight:800;font-size:16px;border-radius:14px}
@media(max-width:360px){.interval-choices{gap:7px}.interval-choice{min-height:72px;font-size:20px}}
/* Custom interval selection */
.interval-custom{display:flex;align-items:center;gap:12px;border:2px solid var(--border);border-radius:15px;padding:14px 16px;background:var(--surface-alt);margin:-5px 0 15px;min-height:76px}
.interval-custom:focus-within,.interval-custom.selected{border-color:var(--orange);box-shadow:inset 0 0 0 1px var(--orange)}
.interval-custom label{flex:1;font-weight:700;color:var(--ink);line-height:1.35}
.interval-custom label small{display:block;color:var(--muted);font-size:12px;font-weight:400;margin-top:4px}
.interval-custom input{width:92px;min-width:0;min-height:48px;border:1px solid var(--border);border-radius:10px;background:var(--surface);color:var(--ink);text-align:center;font-size:22px;font-weight:800;padding:8px}
.interval-error{color:#dc2626;min-height:18px;font-size:13px;margin:0 0 10px}
@media(max-width:360px){.interval-custom{padding:11px;gap:8px}.interval-custom input{width:78px}}

/* Meetpagina iconen: één kleur, licht/donker thema */
:root{--measure-icon:#253044}
:root[data-theme="dark"]{--measure-icon:#FFFFFF}
.measuregrid .tile .symbol{color:var(--measure-icon)!important}
.measuregrid .tile .symbol svg *{stroke:currentColor!important;fill:none!important}
.measuregrid .tile .symbol svg circle,.measuregrid .tile .symbol svg .fill-icon{fill:currentColor!important;stroke:none!important}

/* Meetpagina: zelfde 1/3 icoon + 2/3 content styling als dashboard, zonder dashboard te wijzigen */
.measuregrid{display:grid;grid-template-columns:1fr 1fr;gap:14px}
.measuregrid .tile{position:relative;border:1px solid var(--border);border-radius:18px;padding:0;background:var(--surface);box-shadow:0 8px 20px var(--shadow);display:grid;grid-template-columns:32% 68%;align-items:stretch;min-height:132px;overflow:hidden}
.measuregrid .tile .tileicon{display:flex;align-items:center;justify-content:center;padding:18px}
.measuregrid .tile .tileicon .iconwrap{width:58px;height:58px;flex:0 0 58px;border-radius:16px;background:rgba(37,48,68,.05);display:flex;align-items:center;justify-content:center}
:root[data-theme="dark"] .measuregrid .tile .tileicon .iconwrap{background:rgba(255,255,255,.06)}
.measuregrid .tile .tilecontent{display:flex;flex-direction:column;justify-content:center;padding:18px 16px 18px 6px;min-width:0}
.measuregrid .tile .label{font-size:12px;margin-bottom:6px}
.measuregrid .tile .value{font-size:17px;font-weight:800;line-height:1.15;margin:0 0 8px;overflow-wrap:anywhere}
.measuregrid .tile .sub{font-size:14px;line-height:1.35;margin:0}
.measuregrid .tile .symbol{display:flex;align-items:center;justify-content:center}
.measuregrid .tile .symbol svg{width:30px;height:30px}
@media(max-width:380px){.measuregrid{grid-template-columns:1fr}.measuregrid .tile{min-height:118px}}

/* Grafiekenpagina */
.chartwrap{padding:17px}.chartwrap h1{font-size:23px;margin:0 0 5px}.chartintro{font-size:13px;color:var(--muted);margin:0 0 16px}.chartpanel{background:var(--surface);border:1px solid var(--border);border-radius:17px;padding:16px;margin-bottom:13px;box-shadow:0 5px 16px var(--shadow)}
.chartlabel{display:block;font-size:12px;color:var(--muted);margin-bottom:8px}.chartselect{width:100%;border:1px solid var(--border);background:var(--surface-alt);color:var(--ink);border-radius:12px;padding:13px 14px;font-weight:700;min-height:48px}.metricbuttons{display:grid;grid-template-columns:1fr 1fr;gap:8px}.metricbuttons button{min-height:46px;border-radius:11px;background:var(--surface-alt);color:var(--ink);border:1px solid var(--border);font-weight:700}.metricbuttons button.active{background:var(--orange);border-color:var(--orange);color:#232323}.charthead{display:flex;align-items:flex-start;justify-content:space-between;gap:12px;margin-bottom:10px}.charthead h2{margin:0;font-size:17px}.chartvalue{text-align:right}.chartvalue strong{display:block;font-size:23px;line-height:1}.chartvalue small{color:var(--muted);font-size:11px}.chartbox{position:relative;height:245px;border-radius:13px;background:var(--surface-alt);overflow:hidden;border:1px solid var(--border)}.chartbox svg{width:100%;height:100%;display:block}.chart-empty{height:245px;display:flex;align-items:center;justify-content:center;text-align:center;color:var(--muted);font-size:13px;padding:30px}.chartgridline{stroke:var(--border);stroke-width:1}.chartline{fill:none;stroke:var(--orange);stroke-width:3;stroke-linecap:round;stroke-linejoin:round}.chartarea{fill:var(--orange);opacity:.10}.chartdot{fill:var(--orange);stroke:var(--surface);stroke-width:2}.chartaxis{fill:var(--muted);font-size:10px}.chartstats{display:grid;grid-template-columns:repeat(3,1fr);gap:8px;margin-top:12px}.chartstat{background:var(--surface-alt);border-radius:11px;padding:10px;text-align:center}.chartstat small{display:block;color:var(--muted);font-size:10px;margin-bottom:4px}.chartstat strong{font-size:14px}.chartnote{font-size:11px;color:var(--muted);line-height:1.45;margin-top:10px}
.nav .chartNavIcon{font-size:33px;font-weight:700;letter-spacing:-2px}

@media (prefers-reduced-motion:reduce){.themeswitch::before,.themeswitch button,.themeglyph{transition:none!important}}

/* Data page theme repair — layout untouched */
#data .overviewcard,#data .sessionlist,#data .filterpanel{background:var(--surface);border-color:var(--border);color:var(--ink)}
#data .sessionrow{border-color:var(--border)}
#data .periodpill,#data .searchbox,#data .filterbtn,#data .filteroption,#data .fileicon{background:var(--surface-alt);border-color:var(--border);color:var(--ink)}
#data .searchbox input{color:var(--ink)}
#data .searchbox input::placeholder{color:var(--muted);opacity:1}
#data .overviewvalue,#data .sectionhead,#data .sessiontitle,#data .filterlabel{color:var(--ink)}
#data .overviewlabel,#data .sessionmeta,#data .sessionsub,#data .periodpill{color:var(--muted)}
#data .miniicon,#data .fileicon{color:var(--ink)}
#data .filterbtn.active,#data .filteroption.active{border-color:var(--orange);background:color-mix(in srgb,var(--orange) 18%,var(--surface));color:var(--ink)}
#data .csvbtn{background:var(--orange);color:#232323}
:root[data-theme="dark"] #data .overviewcard,:root[data-theme="dark"] #data .sessionlist,:root[data-theme="dark"] #data .filterpanel{box-shadow:0 2px 10px rgba(0,0,0,.18)}


/* Mobile responsiveness improvements */
@media (max-width: 430px){
  .app{max-width:100%;}
  .top{padding:calc(env(safe-area-inset-top) + 12px) 14px 12px;min-height:64px}
  .brand{font-size:21px}
  .top button{font-size:24px;padding:2px 5px}
  .datawrap{padding:14px 12px calc(128px + env(safe-area-inset-bottom))}
  .datatop{align-items:center;margin-bottom:12px}
  .datatop h1{font-size:17px}
  .periodpill{padding:8px 10px;font-size:11px;border-radius:10px}
  .overviewgrid{grid-template-columns:1fr 1fr;gap:10px;margin-bottom:18px}
  .overviewcard{padding:12px;min-height:104px}
  .overviewcard:nth-child(3){grid-column:1 / -1;display:grid;grid-template-columns:auto 1fr;column-gap:10px;align-items:center;min-height:82px}
  .overviewcard:nth-child(3) .overviewiconrow{grid-row:1 / span 2;margin:0}
  .overviewcard:nth-child(3) .overviewvalue{align-self:end;margin:0}
  .overviewcard:nth-child(3) .overviewlabel{align-self:start}
  .overviewvalue{font-size:25px}
  .overviewlabel{font-size:11px}
  .sectionhead{font-size:17px;margin-bottom:10px}
  .filetoolbar{display:grid;grid-template-columns:1fr auto;gap:8px;margin-bottom:10px}
  .searchbox{height:42px;border-radius:11px;padding:0 11px;min-width:0}
  .searchbox input{font-size:13px}
  .filterbtn{height:42px;border-radius:11px;padding:0 12px;font-size:13px;white-space:nowrap}
  .filterpanel{margin-top:0}
  .sessionlist{border-radius:15px}
  .sessionrow{grid-template-columns:36px minmax(0,1fr) auto;gap:10px;padding:14px 12px;align-items:center}
  .fileicon{width:36px;height:36px;border-radius:10px}
  .fileicon svg{width:19px;height:19px}
  .sessiontitle{font-size:13px;margin-bottom:4px;white-space:normal;overflow-wrap:anywhere}
  .sessionmeta,.sessionsub{font-size:11px;line-height:1.4}
  .csvbtn{height:34px;padding:0 10px;font-size:11px;border-radius:9px;gap:5px}
  .csvbtn svg{width:13px;height:13px}
  .nav{width:100%;border-radius:14px 14px 0 0;padding:8px 0 calc(22px + env(safe-area-inset-bottom))}
  .nav button{min-height:52px;padding:4px 0}
  .nav button span{font-size:29px}
  .nav button .homeNavIcon{font-size:34px}
  .nav button .chartNavIcon{height:28px;width:32px}
}
@media (max-width: 360px){
  .overviewgrid{grid-template-columns:1fr;}
  .overviewcard:nth-child(3){grid-column:auto;display:block;min-height:96px}
  .overviewcard:nth-child(3) .overviewiconrow{margin-bottom:7px}
  .filetoolbar{grid-template-columns:1fr}
  .filterbtn{width:100%;justify-content:center}
  .sessionrow{grid-template-columns:32px minmax(0,1fr);}
  .fileicon{width:32px;height:32px}
  .csvbtn{grid-column:2;justify-self:start;margin-top:7px}
}

/* FINAL mobile override: keep all three overview tiles in one row */
@media (max-width:520px){
  #data .overviewgrid{
    display:grid!important;
    grid-template-columns:repeat(3,minmax(0,1fr))!important;
    gap:7px!important;
  }
  #data .overviewcard,
  #data .overviewcard:nth-child(3){
    grid-column:auto!important;
    display:block!important;
    min-width:0!important;
    min-height:88px!important;
    padding:9px 7px!important;
  }
  #data .overviewcard:nth-child(3) .overviewiconrow{
    grid-row:auto!important;
    margin-bottom:5px!important;
  }
  #data .overviewiconrow{
    min-height:14px!important;
    margin-bottom:5px!important;
  }
  #data .miniicon,#data .miniicon svg{width:14px!important;height:14px!important;}
  #data .overviewvalue{
    font-size:16px!important;
    line-height:1.05!important;
    margin-bottom:3px!important;
    white-space:normal!important;
    overflow-wrap:anywhere!important;
  }
  #data .overviewlabel{
    font-size:9.5px!important;
    line-height:1.1!important;
    white-space:normal!important;
  }
}
@media (max-width:350px){
  #data .overviewgrid{gap:5px!important;}
  #data .overviewcard,#data .overviewcard:nth-child(3){padding:8px 6px!important;min-height:84px!important;}
  #data .overviewvalue{font-size:15px!important;}
  #data .overviewlabel{font-size:9px!important;}
}

/* Verbindingshulp wanneer de Arduino niet meer bereikbaar is */
.connectionlost{position:fixed;inset:0;z-index:100;background:var(--bg);color:var(--ink);display:none;overflow:auto;padding:calc(env(safe-area-inset-top) + 20px) 16px calc(env(safe-area-inset-bottom) + 28px)}
.connectionlost.show{display:block}
.connectionlost-inner{width:min(100%,520px);margin:0 auto}
.connectionlost-brand{font-size:22px;font-weight:800;color:var(--ink);margin-bottom:34px}.connectionlost-brand span{color:var(--orange)}
.connectionlost-icon{width:72px;height:72px;border-radius:22px;background:var(--surface);border:1px solid var(--border);display:flex;align-items:center;justify-content:center;margin:0 0 20px;box-shadow:0 8px 24px var(--shadow);color:var(--navy)}
.connectionlost-icon svg{width:38px;height:38px}
.connectionlost h1{font-size:25px;line-height:1.18;margin:0 0 12px}
.connectionlost>div p,.connectionlost-inner>p{color:var(--muted);font-size:14px;line-height:1.55;margin:0 0 20px}
.connectionchecklist{display:grid;gap:10px;margin:20px 0}
.connectioncheck{display:grid;grid-template-columns:38px 1fr;gap:12px;align-items:start;background:var(--surface);border:1px solid var(--border);border-radius:16px;padding:14px;box-shadow:0 3px 12px var(--shadow)}
.connectioncheck-num{width:38px;height:38px;border-radius:12px;background:var(--surface-alt);display:flex;align-items:center;justify-content:center;font-weight:800;color:var(--navy)}
.connectioncheck b{display:block;font-size:14px;margin:1px 0 4px}.connectioncheck small{display:block;color:var(--muted);font-size:12px;line-height:1.45}
.connectionwifi{background:color-mix(in srgb,var(--orange) 13%,var(--surface));border:1px solid color-mix(in srgb,var(--orange) 48%,var(--border));border-radius:14px;padding:13px 14px;margin:14px 0;font-size:13px;line-height:1.5}
.connectionwifi code{font-family:inherit;font-weight:800;color:var(--ink)}
.connectionactions{display:grid;grid-template-columns:1fr 1fr;gap:10px;margin-top:18px}
.connectionactions button{min-height:52px;border-radius:13px;font-weight:800;padding:0 12px}
.connectionretry{background:var(--orange);color:#232323}.connectionreload{background:var(--surface-alt);color:var(--ink);border:1px solid var(--border)}
.connectionstate{font-size:12px;color:var(--muted);text-align:center;margin-top:12px;min-height:18px}
@media(max-width:360px){.connectionactions{grid-template-columns:1fr}.connectionlost h1{font-size:23px}}

/* ===== Dashboard UI polish ===== */
:root{
  --radius-sm:12px;
  --radius-md:16px;
  --radius-lg:20px;
}

/* Compactere app-header */
.top{
  min-height:68px;
  padding:calc(env(safe-area-inset-top) + 12px) 16px 12px;
}
.brand{font-size:22px}
.topGearBtn{
  width:42px;
  height:42px;
  padding:0!important;
  border-radius:12px;
  display:flex;
  align-items:center;
  justify-content:center;
}
.topGearIcon{width:25px;height:25px;display:block}

/* Minder hoge hero zodat de primaire acties sneller zichtbaar zijn */
.hero{
  height:148px;
  padding:20px 18px;
}
.hero h1{
  font-size:23px;
  line-height:1.1;
}
.hero p{
  margin-top:12px;
  font-size:15px;
}
.hero:after{
  height:64px;
  bottom:18px;
}

/* Compactere systeemstatus */
.system{
  left:14px;
  right:14px;
  padding:9px 12px;
  border-radius:14px 14px 0 0;
  font-size:11px;
  align-items:center;
}
.system .dot{
  width:8px;
  height:8px;
  margin-right:6px;
}

/* Meer balans in primaire dashboardtiles */
.content{
  padding:14px;
}
.homeactions{
  gap:12px;
}
.action{
  min-height:122px;
  border-radius:var(--radius-lg);
  padding:15px 10px;
  gap:9px;
}
.action strong{
  font-size:15px;
  line-height:1.2;
}
.action small{
  font-size:11px;
  line-height:1.35;
  opacity:.9;
}
.action .bigicon{
  width:46px;
  height:46px;
}
.action .bigicon svg{
  width:27px;
  height:27px;
}
.playIconWrap,
.dataIconWrap{
  border-radius:14px;
  display:flex;
  align-items:center;
  justify-content:center;
}
.playIconWrap{
  background:rgba(35,35,35,.14);
  color:#232323;
}
.dataIconWrap{
  background:rgba(255,255,255,.12);
  color:#fff;
}
.actionDataIcon{display:block}

/* Rustigere sectiekop */
.sectiontitle{
  margin:20px 3px 12px;
}
.sectiontitle h2{
  font-size:18px;
}
.live{
  font-size:12px;
}
.live .dot{
  width:8px;
  height:8px;
}

/* Sensorcards: meer ruimte voor de meetwaarde */
.sensors{
  gap:12px;
}
.sensor{
  grid-template-columns:28% 72%;
  min-height:134px;
  border-radius:var(--radius-md);
}
.sensor.compact{
  min-height:124px;
}
.sensoricon{
  padding:14px 10px;
}
.sensoricon .iconwrap{
  width:56px;
  height:56px;
  flex-basis:56px;
  border-radius:14px;
}
.sensorcontent{
  padding:15px 15px 15px 7px;
}
.sensor .label{
  font-size:11px;
  margin-bottom:5px;
}
.sensor .value,
.sensor.emphasis .value{
  font-size:19px;
}
.sensor.compact .value{
  font-size:17px;
}
.sensor .sub{
  font-size:11px;
  margin-top:7px;
  line-height:1.3;
}

/* SD-card in dezelfde visuele familie */
.sd{
  border-radius:var(--radius-md);
  margin-top:12px;
}
.sd .sensoricon .iconwrap{
  width:52px;
  height:52px;
  border-radius:14px;
}

/* Compactere bottom navigation */
.page{
  padding-bottom:calc(100px + env(safe-area-inset-bottom));
}
.nav{
  border-radius:18px 18px 0 0;
  padding:7px 8px calc(14px + env(safe-area-inset-bottom));
  min-height:78px;
  gap:4px;
}
.nav button{
  min-height:48px;
  padding:4px 0;
  border-radius:14px;
  position:relative;
}
.nav button span{
  font-size:0;
}
.navIconWrap,
.nav button>span{
  width:38px;
  height:38px;
  display:flex;
  align-items:center;
  justify-content:center;
  border-radius:12px;
  transition:background .2s ease,color .2s ease,transform .18s ease;
}
.navSvgIcon,
.nav .playIconSvg{
  width:25px;
  height:25px;
}
.nav button .chartNavIcon{
  width:38px;
  height:38px;
  gap:3px;
  align-items:flex-end;
  padding:7px 8px;
}
.nav button .chartNavIcon i{
  width:5px;
}
.nav button.selected>span{
  background:rgba(252,176,49,.14);
}
.nav button.selected{
  color:var(--orange);
}
.nav button:active>span{
  transform:scale(.94);
}

/* iets meer witruimte onder de laatste dashboardcards */
#home .content{
  padding-bottom:24px;
}

/* Alle iconen op mobiel beter in verhouding */
@media(max-width:430px){
  .top{
    min-height:62px;
    padding:calc(env(safe-area-inset-top) + 9px) 14px 9px;
  }
  .brand{font-size:20px}
  .topGearBtn{width:38px;height:38px}
  .topGearIcon{width:23px;height:23px}

  .hero{
    height:132px;
    padding:18px 16px;
  }
  .hero h1{font-size:22px}
  .hero p{font-size:14px;margin-top:10px}

  .system{
    left:12px;
    right:12px;
    padding:8px 10px;
    font-size:10px;
  }

  .content{padding:12px}
  .homeactions{gap:10px}
  .action{
    min-height:112px;
    padding:13px 8px;
    border-radius:18px;
  }
  .action .bigicon{
    width:42px;
    height:42px;
  }
  .action .bigicon svg{
    width:25px;
    height:25px;
  }

  .sensor{
    min-height:126px;
  }
  .sensor.compact{
    min-height:116px;
  }
  .sensoricon .iconwrap{
    width:52px;
    height:52px;
    flex-basis:52px;
  }
  .sensorcontent{
    padding:13px 12px 13px 6px;
  }
  .sensor .value,
  .sensor.emphasis .value{
    font-size:18px;
  }
  .sensor.compact .value{
    font-size:16px;
  }

  .nav{
    min-height:70px;
    padding:6px 8px calc(10px + env(safe-area-inset-bottom));
  }
  .nav button{
    min-height:46px;
  }
  .navIconWrap,
  .nav button>span{
    width:36px;
    height:36px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:24px;
    height:24px;
  }
  .nav button .chartNavIcon{
    width:36px;
    height:36px;
  }
}

/* Op zeer smalle telefoons blijven sensorcards 2 naast elkaar, maar compacter */
@media(max-width:380px){
  #home .sensors{
    grid-template-columns:1fr 1fr;
    gap:9px;
  }
  #home .sensor{
    min-height:118px;
    grid-template-columns:29% 71%;
  }
  #home .sensoricon{
    padding:10px 5px;
  }
  #home .sensoricon .iconwrap{
    width:44px;
    height:44px;
    flex-basis:44px;
  }
  #home .sensorcontent{
    padding:10px 8px 10px 4px;
  }
  #home .sensor .label{
    font-size:10px;
  }
  #home .sensor .value,
  #home .sensor.emphasis .value{
    font-size:16px;
  }
  #home .sensor.compact .value{
    font-size:15px;
  }
  #home .sensor .sub{
    font-size:9.5px;
  }
}

/* ===== Compacte sticky topbar + kleinere onderruimte ===== */

/* Kleur de iOS safe-area bovenaan hetzelfde als de header */
html{
  background:var(--navy);
}
body{
  background:var(--bg);
}
body::before{
  content:"";
  position:fixed;
  top:0;
  left:0;
  right:0;
  height:env(safe-area-inset-top);
  background:var(--navy);
  z-index:49;
  pointer-events:none;
}

/* Header blijft zichtbaar tijdens scrollen */
.top{
  position:sticky;
  top:0;
  z-index:50;
  min-height:56px;
  padding:calc(env(safe-area-inset-top) + 6px) 14px 7px;
  box-shadow:0 2px 8px rgba(0,0,0,.08);
}
.brand{
  font-size:20px;
  line-height:1;
}
.topGearBtn{
  width:36px;
  height:36px;
}
.topGearIcon{
  width:22px;
  height:22px;
}

/* Minder ruimte onderaan de app */
.page{
  padding-bottom:calc(76px + env(safe-area-inset-bottom));
}
.nav{
  min-height:62px;
  padding:4px 8px calc(5px + env(safe-area-inset-bottom));
}
.nav button{
  min-height:42px;
  padding:2px 0;
}
.navIconWrap,
.nav button>span{
  width:34px;
  height:34px;
}
.navSvgIcon,
.nav .playIconSvg{
  width:23px;
  height:23px;
}
.nav button .chartNavIcon{
  width:34px;
  height:34px;
  padding:6px 7px;
}

/* De laatste content hoeft niet zo ver boven de navigatie te stoppen */
#home .content{
  padding-bottom:14px;
}

/* Mobiel nog compacter */
@media(max-width:430px){
  .top{
    min-height:54px;
    padding:calc(env(safe-area-inset-top) + 5px) 12px 6px;
  }
  .brand{font-size:19px}
  .topGearBtn{width:34px;height:34px}
  .topGearIcon{width:21px;height:21px}

  .page{
    padding-bottom:calc(70px + env(safe-area-inset-bottom));
  }
  .nav{
    min-height:58px;
    padding:3px 8px calc(4px + env(safe-area-inset-bottom));
  }
  .nav button{
    min-height:40px;
  }
  .navIconWrap,
  .nav button>span{
    width:32px;
    height:32px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:22px;
    height:22px;
  }
  .nav button .chartNavIcon{
    width:32px;
    height:32px;
  }
}

/* ===== Iets grotere topbar en menu-iconen ===== */
.top{
  min-height:64px;
  padding:calc(env(safe-area-inset-top) + 8px) 16px 9px;
}
.brand{
  font-size:22px;
}
.topGearBtn{
  width:42px;
  height:42px;
}
.topGearIcon{
  width:25px;
  height:25px;
}

/* Grotere iconen in onderste navigatie, zonder de balk weer veel hoger te maken */
.nav button{
  min-height:44px;
}
.navIconWrap,
.nav button>span{
  width:40px;
  height:40px;
}
.navSvgIcon,
.nav .playIconSvg{
  width:28px;
  height:28px;
}
.nav button .chartNavIcon{
  width:40px;
  height:40px;
  padding:6px 7px;
}
.nav button .chartNavIcon i{
  width:5.5px;
}

/* Actieve achtergrond iets ruimer zodat grote iconen niet krap ogen */
.nav button.selected>span{
  border-radius:13px;
}

/* Mobiel */
@media(max-width:430px){
  .top{
    min-height:62px;
    padding:calc(env(safe-area-inset-top) + 7px) 14px 8px;
  }
  .brand{
    font-size:21px;
  }
  .topGearBtn{
    width:40px;
    height:40px;
  }
  .topGearIcon{
    width:24px;
    height:24px;
  }

  .nav button{
    min-height:43px;
  }
  .navIconWrap,
  .nav button>span{
    width:39px;
    height:39px;
  }
  .navSvgIcon,
  .nav .playIconSvg{
    width:27px;
    height:27px;
  }
  .nav button .chartNavIcon{
    width:39px;
    height:39px;
    padding:6px 7px;
  }
}
</style></head><body><div class="app"><header class="top"><div class="brand">Data<span>Logger</span></div><button class="topGearBtn" aria-label="Instellingen openen" onclick="navigate('settings')"><svg class="topGearIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><path d="M12 8.3a3.7 3.7 0 1 0 0 7.4 3.7 3.7 0 0 0 0-7.4Z" stroke="currentColor" stroke-width="1.8"/><path d="M19 13.1v-2.2l-2-.7a7.8 7.8 0 0 0-.8-1.9l.9-1.9-1.6-1.6-1.9.9a7.8 7.8 0 0 0-1.9-.8L11 3H8.9l-.7 2a7.8 7.8 0 0 0-1.9.8l-1.9-.9-1.6 1.6.9 1.9a7.8 7.8 0 0 0-.8 1.9l-2 .7v2.2l2 .7c.2.7.5 1.3.8 1.9l-.9 1.9 1.6 1.6 1.9-.9c.6.3 1.2.6 1.9.8l.7 2H11l.7-2c.7-.2 1.3-.5 1.9-.8l1.9.9 1.6-1.6-.9-1.9c.3-.6.6-1.2.8-1.9l2-.8Z" stroke="currentColor" stroke-width="1.6" stroke-linecap="round" stroke-linejoin="round"/></svg></button></header>
<section id="home" class="page current"><div class="hero"><h1>Welkom terug!</h1><p>Klaar om te meten?</p><div class="system"><span><span class="dot"></span>Systeem online</span><span id="systemSensors">Sensorstatus laden...</span></div></div><div class="content"><div class="homeactions"><button class="action start" onclick="navigate('measure')"><span class="bigicon playIconWrap" aria-hidden="true"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span><strong>Begin met meten</strong><small>Start een nieuwe sessie</small></button><button class="action data" onclick="navigate('data')"><span class="bigicon dataIconWrap" aria-hidden="true"><svg class="actionDataIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><rect x="5" y="4" width="14" height="16" rx="2.5" stroke="currentColor" stroke-width="1.8"/><path d="M8 8h8M8 12h8M8 16h5" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/></svg></span><strong>Bekijk je data</strong><small>Ga naar opgeslagen metingen</small></button></div><div class="sectiontitle"><h2>Live data</h2><span class="live"><span class="dot"></span>Live</span></div><div class="sensors"><article class="sensor emphasis"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M10 14.5V5.5a2 2 0 1 1 4 0v9a4.5 4.5 0 1 1-4 0Z" stroke="#F2A51A" stroke-width="1.8" stroke-linecap="round" stroke-linejoin="round"/><path d="M12 17.75a1.75 1.75 0 1 0 0-3.5 1.75 1.75 0 0 0 0 3.5Z" fill="#F2A51A"/><path d="M16.8 6.4h2.4M16.8 9.4h1.6M16.8 12.4h2.4" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/><path d="M18.6 5.1v7.7" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/><path d="M17.6 5.1h2" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/></svg></span></span></div><div class="sensorcontent"><div class="label">Temperatuur</div><div class="value" id="homeTemp">-- °C</div><div class="sub" id="homeTempDelta">Elke seconde bijgewerkt</div></div></article><article class="sensor emphasis"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" aria-hidden="true" fill="none" xmlns="http://www.w3.org/2000/svg"><defs><linearGradient id="humidityDuoMeasure" x1="7" y1="4" x2="17" y2="21" gradientUnits="userSpaceOnUse"><stop offset="0" stop-color="#8ED9FF"/><stop offset="1" stop-color="#5A5CFF"/></linearGradient></defs><path d="M12 3.2c-.8 1.3-2.4 3.3-4 5.5-1.7 2.2-3 4.3-3 7A7 7 0 0 0 12 22a7 7 0 0 0 7-6.3c0-2.7-1.3-4.8-3-7-1.6-2.2-3.2-4.2-4-5.5Z" fill="url(#humidityDuoMeasure)"/><path d="M8.7 15.5c.4 1.4 1.6 2.6 3 3" stroke="#DFF3FF" stroke-width="1.7" stroke-linecap="round"/><path d="M12 3.2c-.8 1.3-2.4 3.3-4 5.5-1.7 2.2-3 4.3-3 7A7 7 0 0 0 12 22a7 7 0 0 0 7-6.3c0-2.7-1.3-4.8-3-7-1.6-2.2-3.2-4.2-4-5.5Z" stroke="#7FAFEF" stroke-width="1.1"/></svg></span></span></div><div class="sensorcontent"><div class="label">Luchtvochtigheid</div><div class="value" id="homeHum">-- %</div><div class="sub" id="homeHumDelta">Elke seconde bijgewerkt</div></div></article><article class="sensor emphasis"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3 8h10.5c2 0 2.8-2.7 1-3.5-1.2-.6-2.5.2-2.7 1.4" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/><path d="M3 12h15c2.8 0 3.2 4 1 4.8-1.6.6-3.1-.5-3.2-2" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/><path d="M3 16h8" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/></svg></span></span></div><div class="sensorcontent"><div class="label">Windsnelheid</div><div class="value" id="homeWind">-- m/s</div><div class="sub">JL-FS2 · analoog A0</div></div></article><article class="sensor compact"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3.8 6.2 8.8 4l6.4 2.1 5-2.1v13.8l-5 2.2-6.4-2.2-5 2.2V6.2Z" stroke="#31A268" stroke-width="1.6" stroke-linejoin="round"/><path d="M8.8 4v13.8M15.2 6.1V20" stroke="#31A268" stroke-width="1.4"/><path d="M12 8.2c-2 0-3.4 1.4-3.4 3.3 0 2.8 3.4 5.9 3.4 5.9s3.4-3.1 3.4-5.9c0-1.9-1.4-3.3-3.4-3.3Z" fill="#31A268" opacity=".16" stroke="#31A268" stroke-width="1.6"/><circle cx="12" cy="11.5" r="1.3" fill="#31A268"/></svg></span></span></div><div class="sensorcontent"><div class="label">GPS status</div><div class="value" id="homeGps">Wachten</div><div class="sub" id="homeSats">0 satellieten</div></div></article><article class="sensor compact"><div class="sensoricon"><span class="iconwrap"><span class="symbol">◷</span></span></div><div class="sensorcontent"><div class="label">Tijd status</div><div class="value" id="homeTimeStatus">Gesynchroniseerd</div><div class="sub" id="homeTime">--:--:--</div></div></article></div><button class="sd" onclick="navigate('data')"><div class="sensoricon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="#253044" stroke-width="1.8" stroke-linejoin="round" fill="none"/><path d="M14.7 3.8v4.7h4.5" stroke="#253044" stroke-width="1.8" stroke-linejoin="round"/><path d="M9.2 8.1h1.2M11.6 8.1h1.2M14 8.1h1.2" stroke="#253044" stroke-width="1.6" stroke-linecap="round"/><path d="M9.3 11.8h7.5v5.3H9.3z" fill="#253044" opacity=".14" stroke="#253044" stroke-width="1.5"/></svg></span></span></div><div class="sensorcontent"><div class="label">SD status</div><div class="value" id="homeSdStatus">Gereed</div><div class="sub" id="homeSdFree">-- vrij</div></div><span class="arrow">›</span></button></div></section>
<section id="measure" class="page"><div class="sheet"><div style="display:flex;justify-content:space-between;align-items:center;margin-bottom:9px"><button style="background:none;color:var(--navy);font-size:23px" aria-label="Terug naar dashboard" onclick="navigate('home')">‹</button><strong>Meten</strong><span style="width:38px" aria-hidden="true"></span></div><div class="heading"><div><h1 id="headline">Klaar voor nieuwe meetsessie</h1><p>Nieuwe meetsessie</p></div><span class="pill" id="badge">Stand-by</span></div><div class="clock" aria-label="Meetsessiestatistieken"><div class="metric"><span class="metric-label">Verstreken tijd</span><strong id="elapsed">00:00:00</strong></div><div class="metric"><span class="metric-label">Aantal metingen</span><strong id="count">0</strong></div></div><div class="settingrow"><div>⏱ <b>Meetinterval</b><small id="intervalcaption">Elke 1 seconde</small></div><button onclick="changeInterval()">Wijzigen</button></div><div id="activecontrols" class="measureactions hidden"><button class="continue" id="continuebtn" onclick="resumeOrNotice()">▶ Doorgaan</button><button class="pause" id="pausebtn" onclick="togglePause()">Ⅱ Pauzeren</button></div><button id="stopbtn" class="stop hidden" onclick="openStop()">■ &nbsp; Stop sessie</button><button id="startbtn" class="startbtn" onclick="start()"><span aria-hidden="true" style="display:inline-flex;vertical-align:middle;margin-right:7px"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span>START MET METEN</button><div class="measuregrid"><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M10 14.5V5.5a2 2 0 1 1 4 0v9a4.5 4.5 0 1 1-4 0Z" stroke="#F2A51A" stroke-width="1.8" stroke-linecap="round" stroke-linejoin="round"/><path d="M12 17.75a1.75 1.75 0 1 0 0-3.5 1.75 1.75 0 0 0 0 3.5Z" fill="#F2A51A"/><path d="M16.8 6.4h2.4M16.8 9.4h1.6M16.8 12.4h2.4" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/><path d="M18.6 5.1v7.7" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/><path d="M17.6 5.1h2" stroke="#F2A51A" stroke-width="1.6" stroke-linecap="round"/></svg></span></span></div><div class="tilecontent"><div class="label">Temperatuur</div><div class="value" id="measureTemp">-- °C</div><div class="sub" id="measureTempDelta">Live meting</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" aria-hidden="true" fill="none" xmlns="http://www.w3.org/2000/svg"><defs><linearGradient id="humidityMeasureCard" x1="7" y1="4" x2="17" y2="21" gradientUnits="userSpaceOnUse"><stop offset="0" stop-color="#8ED9FF"/><stop offset="1" stop-color="#5A5CFF"/></linearGradient></defs><path d="M12 3.2c-.8 1.3-2.4 3.3-4 5.5-1.7 2.2-3 4.3-3 7A7 7 0 0 0 12 22a7 7 0 0 0 7-6.3c0-2.7-1.3-4.8-3-7-1.6-2.2-3.2-4.2-4-5.5Z" fill="url(#humidityMeasureCard)"/><path d="M8.7 15.5c.4 1.4 1.6 2.6 3 3" stroke="#DFF3FF" stroke-width="1.7" stroke-linecap="round"/><path d="M12 3.2c-.8 1.3-2.4 3.3-4 5.5-1.7 2.2-3 4.3-3 7A7 7 0 0 0 12 22a7 7 0 0 0 7-6.3c0-2.7-1.3-4.8-3-7-1.6-2.2-3.2-4.2-4-5.5Z" stroke="#7FAFEF" stroke-width="1.1"/></svg></span></span></div><div class="tilecontent"><div class="label">Luchtvochtigheid</div><div class="value" id="measureHum">-- %</div><div class="sub" id="measureHumDelta">Live meting</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3 8h10.5c2 0 2.8-2.7 1-3.5-1.2-.6-2.5.2-2.7 1.4" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/><path d="M3 12h15c2.8 0 3.2 4 1 4.8-1.6.6-3.1-.5-3.2-2" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/><path d="M3 16h8" stroke="#31A268" stroke-width="1.8" stroke-linecap="round"/></svg></span></span></div><div class="tilecontent"><div class="label">Windsnelheid</div><div class="value" id="measureWind">-- m/s</div><div class="sub">JL-FS2 · analoog A0</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M3.8 6.2 8.8 4l6.4 2.1 5-2.1v13.8l-5 2.2-6.4-2.2-5 2.2V6.2Z" stroke="#31A268" stroke-width="1.6" stroke-linejoin="round"/><path d="M8.8 4v13.8M15.2 6.1V20" stroke="#31A268" stroke-width="1.4"/><path d="M12 8.2c-2 0-3.4 1.4-3.4 3.3 0 2.8 3.4 5.9 3.4 5.9s3.4-3.1 3.4-5.9c0-1.9-1.4-3.3-3.4-3.3Z" fill="#31A268" opacity=".16" stroke="#31A268" stroke-width="1.6"/><circle cx="12" cy="11.5" r="1.3" fill="#31A268"/></svg></span></span></div><div class="tilecontent"><div class="label">GPS status</div><div class="value" id="measureGps">Wachten</div><div class="sub" id="measureSats">0 satellieten</div></div></div><div class="tile"><div class="tileicon"><span class="iconwrap"><span class="symbol" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="#253044" stroke-width="1.8" stroke-linejoin="round" fill="none"/><path d="M14.7 3.8v4.7h4.5" stroke="#253044" stroke-width="1.8" stroke-linejoin="round"/><path d="M9.2 8.1h1.2M11.6 8.1h1.2M14 8.1h1.2" stroke="#253044" stroke-width="1.6" stroke-linecap="round"/><path d="M9.3 11.8h7.5v5.3H9.3z" fill="#253044" opacity=".14" stroke="#253044" stroke-width="1.5"/></svg></span></span></div><div class="tilecontent"><div class="label">SD kaart <span style="color:var(--green)">●</span></div><div class="value" id="sdwrite">Gereed</div><div class="sub" id="measureSdFree">-- vrij</div></div></div></div><div class="location"><div class="map" aria-label="Huidige GPS-locatie"></div><div class="locationaside"><b>Huidige locatie</b><p id="measureCoords">Geen fix</p><small id="measureAccuracy">Wachten op GPS-satelliet</small></div></div><p class="meta">DataLogger · live verbonden met Arduino UNO R4 WiFi.</p></div></section>
<section id="data" class="page"><div class="datawrap"><div class="datatop"><div><h1>Overzicht</h1></div><button class="periodpill" type="button" onclick="cyclePeriod()" id="periodButton">Laatste 30 dagen ˅</button></div><div class="overviewgrid"><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/><path d="M14.7 3.8v4.7h4.5" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/></svg></span></div><div class="overviewvalue" id="statSessions">12</div><div class="overviewlabel">Sessies</div></div><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M4 18h16M7 18V9m5 9V5m5 13v-7" stroke="currentColor" stroke-width="2" stroke-linecap="round"/></svg></span></div><div class="overviewvalue" id="statMeasurements">3.482</div><div class="overviewlabel">Metingen</div></div><div class="overviewcard"><div class="overviewiconrow"><span class="miniicon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M6.5 6.5A2.5 2.5 0 0 1 9 4h6a2.5 2.5 0 0 1 2.5 2.5v11A2.5 2.5 0 0 1 15 20H9a2.5 2.5 0 0 1-2.5-2.5v-11Z" stroke="currentColor" stroke-width="1.8"/><path d="M9.5 7.5h5M9.5 10.5h5M9.5 13.5h5" stroke="currentColor" stroke-width="1.6" stroke-linecap="round"/></svg></span></div><div class="overviewvalue" id="statSize">248 MB</div><div class="overviewlabel">Totale grootte</div></div></div><h2 class="sectionhead">Meetbestanden</h2><div class="filetoolbar"><label class="searchbox" aria-label="Zoek in sessies"><span aria-hidden="true">⌕</span><input id="searchSessions" type="text" placeholder="Zoek in sessies..." oninput="renderFiles()"></label><button class="filterbtn" id="filterButton" type="button" onclick="toggleFilters()"><span aria-hidden="true"><svg width="18" height="18" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M4 6h16M7 12h10M10 18h4" stroke="currentColor" stroke-width="2" stroke-linecap="round"/></svg></span>Filteren</button></div><div class="filterpanel" id="filterPanel" hidden><span class="filterlabel">Sorteer op</span><div class="filteroptions"><button class="filteroption active" data-sort="newest" onclick="setDataSort('newest')">Nieuwste</button><button class="filteroption" data-sort="oldest" onclick="setDataSort('oldest')">Oudste</button><button class="filteroption" data-sort="largest" onclick="setDataSort('largest')">Grootste</button></div></div><div id="sessionList" class="sessionlist"></div></div></section>
<section id="charts" class="page"><div class="chartwrap"><h1>Grafieken</h1><p class="chartintro">Visualiseer de gegevens uit je opgeslagen meetsessies.</p><div class="chartpanel"><label class="chartlabel" for="chartSession">Meetsessie</label><select id="chartSession" class="chartselect" onchange="renderChart()"><option value="">Selecteer een meetsessie</option></select><div style="height:12px"></div><span class="chartlabel">Meetwaarde</span><div class="metricbuttons"><button id="metricTemp" class="active" onclick="setChartMetric('temperature')">Temperatuur</button><button id="metricHum" onclick="setChartMetric('humidity')">Luchtvochtigheid</button><button id="metricWind" onclick="setChartMetric('wind')">Wind</button></div></div><div class="chartpanel"><div class="charthead"><div><h2 id="chartTitle">Meetverloop</h2><small id="chartSubtitle" style="color:var(--muted)">Kies een meetsessie</small></div><div class="chartvalue"><strong id="chartLatest">--</strong><small id="chartUnit"></small></div></div><div id="chartCanvas" class="chart-empty">Stop eerst een meetsessie. Daarna kun je de opgeslagen data hier plotten.</div><div id="chartStats" class="chartstats" hidden><div class="chartstat"><small>Minimum</small><strong id="chartMin">--</strong></div><div class="chartstat"><small>Gemiddeld</small><strong id="chartAvg">--</strong></div><div class="chartstat"><small>Maximum</small><strong id="chartMax">--</strong></div></div><p class="chartnote">Grafieken worden rechtstreeks opgebouwd uit de CSV-bestanden op de SD-kaart.</p></div></div></section>
<section id="settings" class="page"><div class="settingswrap"><h1>Instellingen</h1>
<div class="settingssection"><h2>Apparaat</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('about')"><span class="settingicon">ⓘ</span><span class="settingcopy"><span class="settingtitle">Over je DataLogger</span><span class="settingdesc">Hardware, sensoren en firmware</span></span><span class="settingright"><span class="chevron">›</span></span></button>
<button class="settingitem" onclick="openModal('system')"><span class="settingicon">◉</span><span class="settingcopy"><span class="settingtitle">Systeemstatus</span><span class="settingdesc">Controleer sensoren en opslag</span></span><span class="settingright"><span class="statusok">Alles gereed</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Tijd &amp; locatie</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('timesync')"><span class="settingicon">◷</span><span class="settingcopy"><span class="settingtitle">Tijdsynchronisatie</span><span class="settingdesc">Voor tijdsafhankelijke metingen</span></span><span class="settingright"><span id="settingsTimeStatus">Gesynchroniseerd</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Metingen</h2><div class="settingscard">
<button class="settingitem" onclick="openModal('interval')"><span class="settingicon">⏱</span><span class="settingcopy"><span class="settingtitle">Standaard meetinterval</span><span class="settingdesc">Tijd tussen twee meetpunten</span></span><span class="settingright"><span id="settingsInterval">1 s</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Data &amp; opslag</h2><div class="settingscard">
<button class="settingitem" onclick="navigate('data')"><span class="settingicon">▣</span><span class="settingcopy"><span class="settingtitle">SD-kaart</span><span class="settingdesc">Opslag en opgeslagen meetsessies</span></span><span class="settingright"><span>31,8 GB vrij</span><span class="chevron">›</span></span></button>
</div></div>
<div class="settingssection"><h2>Weergave</h2><div class="settingscard"><div class="themebuttons"><div class="themeswitch" id="themeSwitch" data-active="light" role="tablist" aria-label="Thema kiezen"><button id="themeLight" type="button" aria-pressed="false" onclick="theme('light')"><span class="themeglyph">☀</span><span>Licht</span></button><button id="themeDark" type="button" aria-pressed="false" onclick="theme('dark')"><span class="themeglyph">☾</span><span>Donker</span></button></div></div></div></div>
<div class="settingssection"><h2>Help</h2><div class="settingscard"><button class="settingitem" onclick="openManualPage()"><span class="settingicon">?</span><span class="settingcopy"><span class="settingtitle">Handleiding Toolkit 3</span><span class="settingdesc">Open de volledige HTML-handleiding</span></span><span class="settingright"><span class="chevron">›</span></span></button></div><button class="walkthroughbtn" onclick="openModal('guide')">▶ &nbsp; Speel Walkthrough af</button></div>
</div></section>
<nav class="nav" aria-label="Hoofdnavigatie"><button class="selected" data-page="home" aria-label="Home" onclick="navigate('home')"><span class="navIconWrap"><svg class="navSvgIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><path d="M4 10.5 12 4l8 6.5V20H14v-5h-4v5H4v-9.5Z" stroke="currentColor" stroke-width="1.9" stroke-linejoin="round"/></svg></span></button><button data-page="measure" aria-label="Meten" onclick="navigate('measure')"><span aria-hidden="true"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span></button><button data-page="data" aria-label="Data" onclick="navigate('data')"><span class="navIconWrap"><svg class="navSvgIcon" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg" aria-hidden="true"><rect x="5" y="4" width="14" height="16" rx="2.3" stroke="currentColor" stroke-width="1.8"/><path d="M8 8h8M8 12h8M8 16h8" stroke="currentColor" stroke-width="1.7" stroke-linecap="round"/></svg></span></button><button data-page="charts" aria-label="Grafieken" onclick="navigate('charts')"><span class="chartNavIcon" aria-hidden="true"><i></i><i></i><i></i></span></button></nav></div>

<div class="manualviewer" id="manualViewer" aria-hidden="true"><div class="manualviewerbar"><strong>Toolkit 3 handleiding</strong><div class="manualvieweractions"><button class="manualviewerpdf" onclick="downloadManualPdf()">PDF</button><button class="manualviewerclose" onclick="closeManualPage()">Sluiten</button></div></div><iframe id="manualFrame" title="Toolkit 3 handleiding" loading="lazy"></iframe></div>
<div class="connectionlost" id="connectionLost" role="dialog" aria-modal="true" aria-labelledby="connectionLostTitle">
  <div class="connectionlost-inner">
    <div class="connectionlost-brand">Data<span>Logger</span></div>
    <div class="connectionlost-icon" aria-hidden="true"><svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M5 9.5a10.5 10.5 0 0 1 14 0M8.2 12.8a5.8 5.8 0 0 1 7.6 0M11 16a1.5 1.5 0 0 1 2 0" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/><path d="M4 4l16 16" stroke="currentColor" stroke-width="1.8" stroke-linecap="round"/></svg></div>
    <h1 id="connectionLostTitle">Je bent niet verbonden met het wifi-signaal van de Arduino-DataLogger.</h1>
    <p>Check de volgende onderdelen om weer connectie te maken.</p>
    <div class="connectionchecklist">
      <div class="connectioncheck"><div class="connectioncheck-num">1</div><div><b>Controleer de stroomvoorziening</b><small>Controleer of de Arduino-DataLogger aan staat en voeding krijgt via USB, powerbank of een geschikte externe voeding.</small></div></div>
      <div class="connectioncheck"><div class="connectioncheck-num">2</div><div><b>Maak opnieuw verbinding met het wifi-signaal</b><small>Open de wifi-instellingen van je telefoon en verbind opnieuw met het netwerk van de DataLogger.</small></div></div>
      <div class="connectioncheck"><div class="connectioncheck-num">3</div><div><b>Herlaad daarna de website</b><small>Zodra je telefoon weer verbonden is met de DataLogger kun je deze pagina opnieuw laden.</small></div></div>
    </div>
    <div class="connectionwifi">Wifi-netwerk: <code>Arduino-Logger</code><br>Wachtwoord: <code>Logger2026!</code></div>
    <div class="connectionactions"><button class="connectionretry" onclick="retryArduinoConnection()">Opnieuw proberen</button><button class="connectionreload" onclick="location.reload()">Website herladen</button></div>
    <div class="connectionstate" id="connectionState">Wachten op verbinding met de Arduino-DataLogger…</div>
  </div>
</div>
<div class="modaloverlay" id="modal"><div class="modal"><header><h2 id="modaltitle">Instellingen</h2><button class="close" aria-label="Sluiten" onclick="closeModal()">✕</button></header><div id="modalbody"></div></div></div><div id="toast" class="toast" role="status"></div>
<script>
let mode='idle',seconds=0,count=0,interval=1,toastTimer,guideStep=0;
let dataSort='newest',dataPeriod=30,chartMetric='temperature',sessions=[],statusData={},sessionCsvCache=new Map();
const $=x=>document.getElementById(x);
let connectionFailures=0,connectionOverlayVisible=false;
const OFFLINE_HELP={title:'Je bent niet verbonden met het wifi-signaal van de Arduino-DataLogger.',steps:['Controleer of de Arduino-DataLogger stroom heeft.','Verbind je telefoon met wifi-netwerk Arduino-Logger.','Herlaad de website nadat de wifi-verbinding hersteld is.'],ssid:'Arduino-Logger'};
try{localStorage.setItem('datalogger-offline-help',JSON.stringify(OFFLINE_HELP));localStorage.setItem('datalogger-last-app-url',location.href)}catch(e){}
function showConnectionLost(){connectionOverlayVisible=true;const el=$('connectionLost');if(el)el.classList.add('show');const st=$('connectionState');if(st)st.textContent='Geen verbinding met de Arduino-DataLogger.'}
function hideConnectionLost(){connectionOverlayVisible=false;const el=$('connectionLost');if(el)el.classList.remove('show');const st=$('connectionState');if(st)st.textContent='Verbonden.'}
function noteConnectionSuccess(){connectionFailures=0;if(connectionOverlayVisible)hideConnectionLost()}
function noteConnectionFailure(){connectionFailures++;if(connectionFailures>=2)showConnectionLost()}
async function retryArduinoConnection(){const st=$('connectionState');if(st)st.textContent='Verbinding controleren…';try{const r=await fetch('/api/status?reconnect='+Date.now(),{cache:'no-store'});if(!r.ok)throw new Error('HTTP '+r.status);const s=await r.json();noteConnectionSuccess();updateUiFromStatus(s);if(st)st.textContent='Verbonden.'}catch(e){showConnectionLost();if(st)st.textContent='Nog geen verbinding. Controleer stroom en wifi.'}}
const esc=s=>String(s??'').replace(/[&<>"']/g,c=>({'&':'&amp;','<':'&lt;','>':'&gt;','"':'&quot;',"'":'&#39;'}[c]));
async function api(url){try{const r=await fetch(url,{cache:'no-store'});if(!r.ok)throw new Error(await r.text()||('HTTP '+r.status));noteConnectionSuccess();return r}catch(e){noteConnectionFailure();throw e}}
async function apiJson(url){return (await api(url)).json()}
function notify(t){$('toast').textContent=t;$('toast').classList.add('show');clearTimeout(toastTimer);toastTimer=setTimeout(()=>$('toast').classList.remove('show'),2500)}
function navigate(id){document.querySelectorAll('.page').forEach(p=>p.classList.toggle('current',p.id===id));document.querySelectorAll('.nav button').forEach(b=>{b.classList.toggle('selected',b.dataset.page===id);b.setAttribute('aria-current',b.dataset.page===id?'page':'false')});if(id==='data')loadSessions();if(id==='charts'){loadSessions().then(()=>{syncChartSessions();renderChart()})}scrollTo(0,0)}
function fmtClock(total){total=Math.max(0,Math.floor(Number(total)||0));let h=String(Math.floor(total/3600)).padStart(2,'0'),m=String(Math.floor(total%3600/60)).padStart(2,'0'),s=String(total%60).padStart(2,'0');return h+':'+m+':'+s}
function fmtSizeBytes(bytes){bytes=Math.max(0,Number(bytes)||0);if(bytes>=1073741824)return (bytes/1073741824).toFixed(1).replace('.',',')+' GB';if(bytes>=1048576)return (bytes/1048576).toFixed(1).replace('.',',')+' MB';if(bytes>=1024)return Math.max(1,Math.round(bytes/1024))+' KB';return bytes+' B'}
function fmtFreeMB(mb){mb=Number(mb);if(!Number.isFinite(mb)||mb<0)return 'SD gereed';if(mb>=1024)return (mb/1024).toFixed(1).replace('.',',')+' GB vrij';return Math.round(mb)+' MB vrij'}
function dateNl(iso){if(!iso)return 'Onbekende datum';const m=String(iso).match(/^(\d{4})-(\d{2})-(\d{2})/);if(!m)return iso;const months=['jan','feb','mrt','apr','mei','jun','jul','aug','sep','okt','nov','dec'];return Number(m[3])+' '+months[Number(m[2])-1]+' '+m[1]}
function updateUiFromStatus(s){statusData=s;mode=(s.state||'idle').toLowerCase();seconds=Number(s.elapsed)||0;count=Number(s.count)||0;interval=(Number(s.intervalMs)||1000)/1000;  $('elapsed').textContent=fmtClock(seconds);$('count').textContent=count.toLocaleString('nl-NL');
  $('headline').textContent=mode==='running'?'Meetsessie actief':mode==='paused'?'Meetsessie gepauzeerd':'Klaar voor nieuwe meetsessie';
  $('badge').textContent=mode==='running'?'Actief':mode==='paused'?'Gepauzeerd':'Stand-by';
  $('badge').style.background=mode==='running'?'#d8f5e3':mode==='paused'?'#fff0d3':'#e9edf3';
  $('activecontrols').classList.toggle('hidden',mode==='idle');$('stopbtn').classList.toggle('hidden',mode==='idle');$('startbtn').classList.toggle('hidden',mode!=='idle');
  $('pausebtn').innerHTML=mode==='paused'?'<span aria-hidden="true" style="display:inline-flex;vertical-align:middle;margin-right:6px"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span>Verder meten':'Ⅱ Pauzeren';$('continuebtn').innerHTML=mode==='paused'?'<span aria-hidden="true" style="display:inline-flex;vertical-align:middle;margin-right:6px"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span>Verder meten':'<span aria-hidden="true" style="display:inline-flex;vertical-align:middle;margin-right:6px"><svg class="playIconSvg" viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M8.5 6.8v10.4c0 .8.9 1.3 1.6.9l8-5.2a1.05 1.05 0 0 0 0-1.8l-8-5.2c-.7-.4-1.6.1-1.6.9Z" fill="currentColor"/></svg></span>Doorgaan';
  $('intervalcaption').textContent='Elke '+String(interval).replace('.',',')+' '+(interval===1?'seconde':'seconden');const si=$('settingsInterval');if(si)si.textContent=String(interval).replace('.',',')+' s';
  const temp=Number(s.temperature),hum=Number(s.humidity),tempText=Number.isFinite(temp)?temp.toFixed(2).replace('.',',')+' °C':'-- °C',humText=Number.isFinite(hum)?hum.toFixed(1).replace('.',',')+' %':'-- %';
  if($('homeTemp'))$('homeTemp').textContent=tempText;if($('measureTemp'))$('measureTemp').textContent=tempText;if($('homeHum'))$('homeHum').textContent=humText;if($('measureHum'))$('measureHum').textContent=humText;const wind=Number(s.windSpeed),windTxt=Number.isFinite(wind)?wind.toFixed(1).replace('.',',')+' m/s':'-- m/s';if($('homeWind'))$('homeWind').textContent=windTxt;if($('measureWind'))$('measureWind').textContent=windTxt;
  const fix=!!s.positionValid,gpsTxt=fix?'Satelliet gevonden':'Geen satelliet gevonden',satTxt=(Number(s.satellites)||0)+' satellieten';if($('homeGps'))$('homeGps').textContent=gpsTxt;if($('measureGps'))$('measureGps').textContent=gpsTxt;if($('homeSats'))$('homeSats').textContent=satTxt;if($('measureSats'))$('measureSats').textContent=satTxt;
  if($('homeTime'))$('homeTime').textContent=s.rtcTime||'--:--:--';if($('homeTimeStatus'))$('homeTimeStatus').textContent=s.rtcSynced?'Gesynchroniseerd':'Synchroniseren';if($('settingsTimeStatus'))$('settingsTimeStatus').textContent=s.rtcSynced?'Gesynchroniseerd':'Synchroniseren';
  const sdOk=!!s.sdReady,free=fmtFreeMB(s.sdFreeMB);if($('homeSdStatus'))$('homeSdStatus').textContent=sdOk?'Gereed':'Fout';if($('homeSdFree'))$('homeSdFree').textContent=free;if($('measureSdFree'))$('measureSdFree').textContent=free;if($('sdwrite'))$('sdwrite').textContent=mode==='running'?'Schrijven...':sdOk?'Gereed':'Fout';
  if($('systemSensors'))$('systemSensors').textContent=(s.shtReady&&s.sdReady&&s.rtcReady)?'Wind + temperatuur actief':'Controleer systeemstatus';
  if($('measureCoords'))$('measureCoords').innerHTML=fix?(Number(s.latitude).toFixed(6)+'° N<br>'+Number(s.longitude).toFixed(6)+'° E'):'Geen actuele positie';if($('measureAccuracy'))$('measureAccuracy').innerHTML=fix?('Bron: '+esc(s.locationSource||'GPS')):'Wachten op GPS-satelliet';
}
async function pollStatus(){try{updateUiFromStatus(await apiJson('/api/status'))}catch(e){if($('systemSensors'))$('systemSensors').textContent='Verbinding verbroken'}}
async function start(){try{await api('/api/start');await pollStatus();notify('Nieuwe meetsessie gestart')}catch(e){notify('Starten mislukt: '+e.message)}}
async function togglePause(){try{await api(mode==='paused'?'/api/resume':'/api/pause');await pollStatus();notify(mode==='paused'?'Meting gepauzeerd':'Status bijgewerkt')}catch(e){notify('Actie mislukt: '+e.message)}}
function resumeOrNotice(){if(mode==='paused')togglePause();else notify('Je bent al aan het meten')}
function openStop(){openModal('stop')}
async function finish(){try{await api('/api/stop');closeModal();await pollStatus();await loadSessions();notify('Meetsessie opgeslagen op SD-kaart')}catch(e){notify('Stoppen mislukt: '+e.message)}}
function getDisplaySessions(){let list=[...sessions];const q=($('searchSessions')?.value||'').trim().toLowerCase();if(q)list=list.filter(f=>('datalogger_meetsessie_'+f.id).includes(q)||String(f.id).includes(q));if(dataPeriod>0){const cutoff=Date.now()-dataPeriod*86400000;list=list.filter(f=>{if(!f.start)return true;const t=Date.parse(f.start.replace(' ','T'));return !Number.isFinite(t)||t>=cutoff})}list.sort((a,b)=>dataSort==='oldest'?a.id-b.id:dataSort==='largest'?b.size-a.size:b.id-a.id);return list}
async function loadSessions(){try{const j=await apiJson('/api/sessions');sessions=Array.isArray(j.sessions)?j.sessions:[];renderFiles();syncChartSessions();return sessions}catch(e){sessions=[];renderFiles();return []}}
function renderFiles(){const list=getDisplaySessions(),root=$('sessionList');if(!root)return;root.replaceChildren();if(!list.length){root.innerHTML='<div class="emptyhint">Geen sessies gevonden.</div>'}else list.forEach(f=>{const row=document.createElement('div');row.className='sessionrow';const icon=document.createElement('div');icon.className='fileicon';icon.innerHTML='<svg viewBox="0 0 24 24" fill="none" xmlns="http://www.w3.org/2000/svg"><path d="M7 3.8h7.7l4.5 4.5v11.9H7V3.8Z" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/><path d="M14.7 3.8v4.7h4.5" stroke="currentColor" stroke-width="1.8" stroke-linejoin="round"/></svg>';const info=document.createElement('div');info.style.minWidth='0';info.innerHTML='<div class="sessiontitle">DataLogger_meetsessie_'+f.id+'</div><div class="sessionmeta">'+esc(dateNl(f.start))+' &nbsp; '+esc(fmtClock(f.duration))+'</div><div class="sessionsub">'+Number(f.count||0).toLocaleString('nl-NL')+' metingen &nbsp; · &nbsp; '+esc(fmtSizeBytes(f.size||0))+'</div>';const btn=document.createElement('button');btn.className='sessionmenubtn';btn.type='button';btn.setAttribute('aria-label','Acties voor meetsessie '+f.id);btn.innerHTML='⋮';btn.onclick=()=>openSessionActions(f);row.append(icon,info,btn);root.appendChild(row)});
  const all=sessions;$('statSessions').textContent=all.length;$('statMeasurements').textContent=all.reduce((a,b)=>a+(Number(b.count)||0),0).toLocaleString('nl-NL');$('statSize').textContent=fmtSizeBytes(all.reduce((a,b)=>a+(Number(b.size)||0),0));}
function sessionByNumber(n){return sessions.find(x=>Number(x.id)===Number(n))}
function toggleFilters(){const p=$('filterPanel'),b=$('filterButton');p.hidden=!p.hidden;b.classList.toggle('active',!p.hidden)}
function setDataSort(s){dataSort=s;document.querySelectorAll('.filteroption').forEach(b=>b.classList.toggle('active',b.dataset.sort===s));renderFiles()}
function cyclePeriod(){const opts=[30,90,365,0],labels={30:'Laatste 30 dagen ˅',90:'Laatste 90 dagen ˅',365:'Laatste jaar ˅',0:'Alle data ˅'};dataPeriod=opts[(opts.indexOf(dataPeriod)+1)%opts.length];$('periodButton').textContent=labels[dataPeriod];renderFiles()}
function openSessionActions(f){$('modaltitle').textContent='Meetsessie '+f.id;$('modalbody').innerHTML='<div class="sessionactionsheet"><button class="sessionaction" onclick="downloadCSVByNumber('+f.id+')"><span class="saicon">⇩</span><span>Downloaden<small>Download als CSV-bestand</small></span></button><button class="sessionaction" onclick="shareSession('+f.id+')"><span class="saicon">↗</span><span>Delen<small>Deel het CSV-bestand</small></span></button><button class="sessionaction" onclick="inspectSession('+f.id+')"><span class="saicon">⌕</span><span>Data inkijken<small>Bekijk alle gemeten waarden</small></span></button><button class="sessionaction danger" onclick="confirmDeleteSession('+f.id+')"><span class="saicon">⌫</span><span>Verwijderen<small>Verwijder deze meetsessie permanent</small></span></button></div>';$('modal').classList.add('open')}
function downloadCSVByNumber(n){location.href='/api/download?id='+encodeURIComponent(n)}
async function getSessionCsv(n,refresh=false){if(!refresh&&sessionCsvCache.has(n))return sessionCsvCache.get(n);const t=await (await api('/api/download?id='+encodeURIComponent(n))).text();sessionCsvCache.set(n,t);return t}
async function shareSession(n){const f=sessionByNumber(n);if(!f)return;try{const text=await getSessionCsv(n,true),file=new File([text],'DataLogger_meetsessie_'+n+'.csv',{type:'text/csv'});if(navigator.canShare&&navigator.canShare({files:[file]})&&navigator.share){await navigator.share({title:'DataLogger meetsessie '+n,files:[file]})}else if(navigator.share){await navigator.share({title:'DataLogger meetsessie '+n,text:'DataLogger_meetsessie_'+n+'.csv'})}else{downloadCSVByNumber(n);notify('Delen niet ondersteund; CSV wordt gedownload')}}catch(e){if(e.name!=='AbortError')notify('Delen mislukt')}}
function parseCSV(text){const lines=text.replace(/\r/g,'').split('\n').filter(Boolean);if(!lines.length)return {headers:[],rows:[]};const headers=lines[0].split(',').map(x=>x.trim());return {headers,rows:lines.slice(1).map(line=>{const a=line.split(',');const o={};headers.forEach((h,i)=>o[h]=a[i]??'');return o})}}
async function inspectSession(n){const f=sessionByNumber(n);if(!f)return;$('modaltitle').textContent='DataLogger_meetsessie_'+n;$('modalbody').innerHTML='<div class="datatableempty">Meetdata laden...</div>';$('modal').classList.add('open');try{const p=parseCSV(await getSessionCsv(n));const rows=p.rows;const pick=(r,...names)=>{for(const k of names)if(k in r)return r[k];return ''};let trs=rows.map((r,i)=>'<tr><td class="num">'+esc(pick(r,'measurement_id')||i+1)+'</td><td>'+esc((pick(r,'rtc_datetime_local')||'').split(' ')[1]||pick(r,'rtc_datetime_local'))+'</td><td class="num">'+esc(pick(r,'temperature_C'))+'</td><td class="num">'+esc(pick(r,'humidity_pct'))+'</td><td class="num">'+esc(pick(r,'wind_speed_ms'))+'</td><td class="num">'+esc(pick(r,'latitude'))+'</td><td class="num">'+esc(pick(r,'longitude'))+'</td></tr>').join('');if(!trs)trs='<tr><td colspan="7" class="datatableempty">Deze sessie bevat nog geen meetpunten.</td></tr>';$('modalbody').innerHTML='<div class="datatablewrap"><table class="datatable"><thead><tr><th>#</th><th>Tijd</th><th class="num">Temp °C</th><th class="num">RV %</th><th class="num">Wind m/s</th><th class="num">Latitude</th><th class="num">Longitude</th></tr></thead><tbody>'+trs+'</tbody></table></div>'}catch(e){$('modalbody').innerHTML='<div class="datatableempty">Data laden mislukt: '+esc(e.message)+'</div>'}}
function confirmDeleteSession(n){const f=sessionByNumber(n);if(!f)return;$('modaltitle').textContent='Meetsessie verwijderen?';$('modalbody').innerHTML='<p style="font-size:13px;color:var(--muted);line-height:1.5">DataLogger_meetsessie_'+n+' wordt permanent van de SD-kaart verwijderd. Dit kan niet ongedaan worden gemaakt.</p><div class="measureactions"><button class="continue" onclick="openSessionActions(sessionByNumber('+n+'))">Annuleren</button><button class="stop" onclick="deleteSession('+n+')">Verwijderen</button></div>'}
async function deleteSession(n){try{await api('/api/delete?id='+encodeURIComponent(n));sessionCsvCache.delete(n);closeModal();await loadSessions();notify('Meetsessie verwijderd')}catch(e){notify('Verwijderen mislukt: '+e.message)}}
function changeInterval(){openModal('interval')}
function closeModal(){$('modal').classList.remove('open')}
function openManualPage(){const v=$('manualViewer'),f=$('manualFrame');if(f&&!f.src)f.src='/handleiding';if(v){v.classList.add('open');v.setAttribute('aria-hidden','false');document.body.style.overflow='hidden'}}
function closeManualPage(){const v=$('manualViewer');if(v){v.classList.remove('open');v.setAttribute('aria-hidden','true');document.body.style.overflow=''}}
function downloadManualPdf(){window.open('/handleiding?print=1','_blank')}

const GUIDE_STEPS=[
{title:'Welkom bij DataLogger',eyebrow:'Stap 1 van 5',body:`<div class="guidehero"><span class="guideeyebrow">◉ Klaar om te starten</span><h3>We helpen je in een paar stappen op weg.</h3><p>Deze walkthrough laat zien hoe je de tijd synchroniseert, navigeert in de app en een meetsessie correct uitvoert.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">⌂</div><div><b>Home</b><small>Bekijk live sensordata en start snel een sessie.</small></div></div><div class="guideitem"><div class="guideitemicon">▶</div><div><b>Meten</b><small>Voer je meetsessie uit, pauzeer of stop en sla op.</small></div></div><div class="guideitem"><div class="guideitemicon">▤</div><div><b>Data & grafieken</b><small>Download CSV-bestanden en bekijk trends van opgeslagen sessies.</small></div></div></div>`},
{title:'Synchroniseer de tijd',eyebrow:'Stap 2 van 5',body:`<div class="guidehero"><span class="guideeyebrow">◷ Tijd is belangrijk</span><h3>Zorg eerst voor correcte tijdsafhankelijke metingen.</h3><p>Synchroniseer de tijd van je DataLogger met deze telefoon voordat je een nieuwe sessie start.</p></div><div class="guidecard"><h4>Waarom dit nodig is</h4><p>Alle metingen en CSV-bestanden krijgen een tijdstempel. Een correcte klok voorkomt verwarring tijdens analyse.</p></div><div class="guideinline"><button class="modalaction" onclick="syncTimeFromPhone()">Synchroniseer tijd</button></div>`},
{title:'Kies je weergave',eyebrow:'Stap 3 van 5',body:`<div class="guidehero"><span class="guideeyebrow">☀ / ☾ Weergave</span><h3>Kies het thema dat jij prettig vindt.</h3><p>Je keuze wordt onthouden op dit apparaat.</p></div><div class="guidethemeinline" id="guideThemeSwitch" data-active="__THEME_ACTIVE__"><button class="__LIGHT_ACTIVE__" onclick="guideThemeSwitch('light')">☀ Licht thema</button><button class="__DARK_ACTIVE__" onclick="guideThemeSwitch('dark')">☾ Donker thema</button></div><div class="guidecard"><h4>Goed om te weten</h4><p>Het thema verandert alleen de app-weergave en heeft geen invloed op je metingen of opgeslagen data.</p></div>`},
{title:'Zo voer je een meetsessie uit',eyebrow:'Stap 4 van 5',body:`<div class="guidehero"><span class="guideeyebrow">▶ Meten</span><h3>Meten werkt in drie eenvoudige acties.</h3><p>Open de Meet-pagina om een sessie te starten. Je ziet daar ook het interval, live sensorstatus en de GPS-locatie van de Air530Z.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">1</div><div><b>Start met meten</b><small>Begint een nieuwe sessie en zet de teller op nul.</small></div></div><div class="guideitem"><div class="guideitemicon">2</div><div><b>Pauzeren / verder meten</b><small>Pauzeer tijdelijk als je geen onnodige meetpunten wilt opslaan.</small></div></div><div class="guideitem"><div class="guideitemicon">3</div><div><b>Stop sessie</b><small>Slaat je sessie definitief op zodat deze beschikbaar wordt in Data en Grafieken.</small></div></div></div>`},
{title:'Je bent klaar',eyebrow:'Stap 5 van 5',body:`<div class="guidehero"><span class="guideeyebrow">✓ Klaar voor gebruik</span><h3>Je DataLogger is klaar om te meten.</h3><p>Ga nu naar Home voor een overzicht of open direct de Meet-pagina om een nieuwe sessie te starten.</p></div><div class="guidelist"><div class="guideitem"><div class="guideitemicon">⤓</div><div><b>Data</b><small>Download, deel en inspecteer CSV-bestanden van opgeslagen sessies.</small></div></div><div class="guideitem"><div class="guideitemicon">▥</div><div><b>Grafieken</b><small>Visualiseer temperatuur en luchtvochtigheid per sessie.</small></div></div></div><div class="guidecallout">Je kunt deze walkthrough later opnieuw starten via Instellingen → Help.</div>`}
];
function renderGuide(){const step=GUIDE_STEPS[guideStep];$('modaltitle').textContent=step.title;let body=step.body;if(guideStep===2){const dark=document.documentElement.getAttribute('data-theme')==='dark';body=body.replace('__LIGHT_ACTIVE__',dark?'':'active').replace('__DARK_ACTIVE__',dark?'active':'').replace('__THEME_ACTIVE__',dark?'dark':'light')}$('modalbody').innerHTML=body+`<div class="guideprogress"><small>${step.eyebrow}</small><div class="guidedots">${GUIDE_STEPS.map((_,i)=>`<span class="guidedot ${i===guideStep?'active':''}"></span>`).join('')}</div></div><div class="guideactions"><button class="guidebtn secondary" ${guideStep===0?'disabled':''} onclick="guidePrev()">Terug</button><div class="guideactionstack">${guideStep<GUIDE_STEPS.length-1?'<button class="guidebtn primary" onclick="guideNext()">Volgende</button>':'<button class="guidebtn primary" onclick="closeModal();navigate(\'home\')">Open dashboard</button>'}</div></div>`}
function guideNext(){if(guideStep<GUIDE_STEPS.length-1){guideStep++;renderGuide()}}
function guidePrev(){if(guideStep>0){guideStep--;renderGuide()}}
function guideThemeSwitch(name){const sw=$('guideThemeSwitch');if(sw){const dark=name==='dark';sw.dataset.active=dark?'dark':'light';const b=sw.querySelectorAll('button');b[0]?.classList.toggle('active',!dark);b[1]?.classList.toggle('active',dark)}theme(name)}
async function syncTimeFromPhone(){const d=new Date(),q=`/api/time?y=${d.getFullYear()}&mo=${d.getMonth()+1}&d=${d.getDate()}&h=${d.getHours()}&mi=${d.getMinutes()}&s=${d.getSeconds()}`;try{await api(q);await pollStatus();const m=$('modalTimeState');if(m)m.textContent='Zojuist gesynchroniseerd';const p=$('phoneTimePreview');if(p)p.textContent=d.toLocaleTimeString('nl-NL');notify('Tijd gesynchroniseerd met telefoon')}catch(e){notify('Synchroniseren mislukt')}}
function theme(name){const c=name==='dark'?'dark':'light';document.documentElement.setAttribute('data-theme',c);try{localStorage.setItem('datalogger-theme',c)}catch(e){}$('themeLight')?.setAttribute('aria-pressed',String(c==='light'));$('themeDark')?.setAttribute('aria-pressed',String(c==='dark'));const sw=$('themeSwitch');if(sw)sw.dataset.active=c;$('browserThemeColor').setAttribute('content',c==='dark'?'#232323':'#343F58')}
function chooseInterval(n){window.pendingInterval=n;$('customSeconds').value='';$('intervalCustom').classList.remove('selected');$('intervalError').textContent='';document.querySelectorAll('.interval-choice').forEach(b=>b.setAttribute('aria-pressed',String(Number(b.querySelector('span').textContent)===n)));$('intervalHelp').textContent='Iedere '+String(n).replace('.',',')+' seconde(n) een meetpunt.'}
function customIntervalChanged(){const input=$('customSeconds'),raw=input.value.trim().replace(',','.'),n=Number(raw),valid=/^\d+(?:\.\d{1,3})?$/.test(raw)&&n>=0.1&&n<=2147483&&Number.isInteger(Math.round(n*1000));document.querySelectorAll('.interval-choice').forEach(b=>b.setAttribute('aria-pressed','false'));$('intervalCustom').classList.toggle('selected',valid);$('intervalError').textContent=raw&&!valid?'Vul minimaal 0,1 seconde in, met maximaal drie decimalen.':'';window.pendingInterval=valid?n:null;$('intervalHelp').textContent=valid?'Iedere '+String(n).replace('.',',')+' seconde(n) een meetpunt.':'Vul zelf je interval in, bijvoorbeeld 0,1, 0,25 of 120.'}
async function saveInterval(){const n=window.pendingInterval;if(!Number.isFinite(n)||n<0.1){$('intervalError').textContent='Kies minimaal 0,1 seconde.';return}try{await api('/api/interval?ms='+Math.round(n*1000));closeModal();await pollStatus();notify('Meetinterval gewijzigd naar '+String(n).replace('.',',')+' s')}catch(e){notify('Interval opslaan mislukt')}}
function openModal(which){const title=$('modaltitle'),body=$('modalbody');body.replaceChildren();if(which==='stop'){title.textContent='Meetsessie stoppen?';body.innerHTML='<p>Je sluit deze meetsessie definitief af en bewaart de gegevens. Pauzeren houdt dezelfde sessie open.</p><div class="measureactions"><button class="continue" onclick="closeModal()">Annuleren</button><button class="stop" onclick="finish()">Stop en bewaar</button></div>'}
else if(which==='interval'){title.textContent='Meetinterval';body.innerHTML='<p class="interval-intro">Kies hoe vaak je DataLogger een nieuw meetpunt opslaat.</p><div class="interval-choices" id="intervalChoices" role="group" aria-label="Meetinterval kiezen"></div><div class="interval-custom" id="intervalCustom"><label for="customSeconds">Zelf aantal seconden invullen<small>Ook decimalen mogelijk, bijvoorbeeld 0,1 of 0,25 seconde</small></label><input id="customSeconds" type="text" inputmode="decimal" autocomplete="off" placeholder="bijv. 0,1" oninput="customIntervalChanged()"></div><p class="interval-error" id="intervalError" role="alert"></p><div class="interval-help" id="intervalHelp"></div><button class="startbtn interval-save" onclick="saveInterval()">Interval opslaan</button>';window.pendingInterval=interval;[0.1,0.5,1,2,5,10,30,60].forEach(n=>{const b=document.createElement('button');b.className='interval-choice';b.type='button';b.setAttribute('aria-pressed',String(n===interval));b.innerHTML='<span>'+n+'</span><small>'+(n===1?'seconde':'seconden')+'</small>';b.onclick=()=>chooseInterval(n);$('intervalChoices').appendChild(b)});if(![0.1,0.5,1,2,5,10,30,60].includes(interval)){$('customSeconds').value=String(interval).replace('.',',');customIntervalChanged()}else chooseInterval(interval)}
else if(which==='system'){title.textContent='Systeemstatus';const s=statusData;body.innerHTML='<div class="modalinfo"><div class="modalinforow"><span>SHT31 temperatuur</span><span>'+(s.shtReady?'Actief':'Niet gevonden')+'</span></div><div class="modalinforow"><span>Air530Z GPS</span><span>'+(s.gpsSeen?'NMEA actief':'Geen data')+'</span></div><div class="modalinforow"><span>SD-kaart</span><span>'+(s.sdReady?'Gereed':'Fout')+'</span></div><div class="modalinforow"><span>DS1307 tijd</span><span>'+(s.rtcReady?'Actief':'Niet gevonden')+'</span></div><div class="modalinforow"><span>WiFi</span><span>Arduino-Logger-03</span></div></div>'}
else if(which==='timesync'){title.textContent='Synchroniseer de tijd';body.innerHTML='<p style="font-size:13px;color:var(--muted);line-height:1.5">Synchroniseer de tijd van je DataLogger met de actuele tijd van deze telefoon. Dit is belangrijk voor tijdsafhankelijke metingen.</p><div class="modalinfo"><div class="modalinforow"><span>Status</span><span id="modalTimeState">'+(statusData.rtcSynced?'Gesynchroniseerd':'Nog synchroniseren')+'</span></div><div class="modalinforow"><span>Telefoontijd</span><span id="phoneTimePreview">'+new Date().toLocaleTimeString('nl-NL')+'</span></div></div><button class="modalaction" onclick="syncTimeFromPhone()">Synchroniseer tijd</button>'}
else if(which==='about'){title.textContent='Over je DataLogger';body.innerHTML='<section><b>Arduino UNO R4 WiFi</b><p>Microcontroller en lokaal WiFi-netwerk.</p></section><section><b>Grove Air530Z</b><p>GPS-positie, snelheid en UTC-tijd via UART.</p></section><section><b>Grove SHT31</b><p>Temperatuur en luchtvochtigheid via I²C.</p></section><section><b>DFRobot JL-FS2</b><p>Windsnelheid via 0–5 V analoge uitgang op A0. Externe 9–24 V voeding met gedeelde GND.</p></section><section><b>Keyes Logging Shield</b><p>SD-kaart en DS1307-klok met reservebatterij.</p></section>'}
else if(which==='guide'){guideStep=0;renderGuide()}$('modal').classList.add('open')}
function syncChartSessions(){const sel=$('chartSession');if(!sel)return;const prev=sel.value;sel.innerHTML='<option value="">Selecteer een meetsessie</option>';sessions.forEach(f=>{const o=document.createElement('option');o.value=String(f.id);o.textContent='Meetsessie '+f.id+' · '+Number(f.count||0).toLocaleString('nl-NL')+' meetpunten';sel.appendChild(o)});if(sessions.some(f=>String(f.id)===prev))sel.value=prev;else if(sessions.length)sel.value=String(sessions[0].id)}
function setChartMetric(metric){chartMetric=metric;[['metricTemp','temperature'],['metricHum','humidity'],['metricWind','wind']].forEach(([id,k])=>{const b=$(id);if(b)b.classList.toggle('active',metric===k)});renderChart()}
function fmtChartTime(sec){if(sec<60)return Math.round(sec)+' s';if(sec<3600)return Math.round(sec/60)+' min';return (sec/3600).toFixed(1).replace('.',',')+' u'}
async function renderChart(){const canvas=$('chartCanvas'),stats=$('chartStats'),select=$('chartSession');if(!canvas||!select)return;const id=Number(select.value);if(!id){canvas.className='chart-empty';canvas.innerHTML='Kies een opgeslagen meetsessie.';stats.hidden=true;return}canvas.className='chart-empty';canvas.innerHTML='Meetdata laden...';try{const parsed=parseCSV(await getSessionCsv(id)),map={temperature:['temperature_C','°C','Temperatuur',1],humidity:['humidity_pct','%','Luchtvochtigheid',0],wind:['wind_speed_ms','m/s','Windsnelheid',1]},cfg=map[chartMetric]||map.temperature,vals=parsed.rows.map(r=>Number(r[cfg[0]])).filter(Number.isFinite);if(!vals.length)throw new Error('Geen geldige '+cfg[2].toLowerCase()+'data');let min=Math.min(...vals),max=Math.max(...vals);if(max-min<.5){min-=.25;max+=.25}const pad=(max-min)*.14;min-=pad;max+=pad;const w=360,h=220,left=40,right=12,top=16,bottom=30,pw=w-left-right,ph=h-top-bottom,x=i=>left+(i/(vals.length-1||1))*pw,y=v=>top+(max-v)/(max-min)*ph;const pts=vals.map((v,i)=>x(i).toFixed(1)+','+y(v).toFixed(1)).join(' '),area=left+','+(top+ph)+' '+pts+' '+(left+pw)+','+(top+ph);let grid='';for(let i=0;i<=4;i++){const yy=top+i*ph/4,val=max-i*(max-min)/4;grid+='<line class="chartgridline" x1="'+left+'" x2="'+(left+pw)+'" y1="'+yy+'" y2="'+yy+'"/><text class="chartaxis" x="4" y="'+(yy+3)+'">'+val.toFixed(cfg[3])+'</text>'}const last=vals[vals.length-1];canvas.className='chartbox';canvas.innerHTML='<svg viewBox="0 0 '+w+' '+h+'">'+grid+'<polygon class="chartarea" points="'+area+'"/><polyline class="chartline" points="'+pts+'"/><circle class="chartdot" cx="'+x(vals.length-1)+'" cy="'+y(last)+'" r="4"/></svg>';$('chartTitle').textContent=cfg[2];$('chartSubtitle').textContent='Meetsessie '+id+' · '+vals.length+' meetpunten';$('chartLatest').textContent=last.toFixed(cfg[3]).replace('.',',');$('chartUnit').textContent=cfg[1];const avg=vals.reduce((a,b)=>a+b,0)/vals.length;$('chartMin').textContent=Math.min(...vals).toFixed(cfg[3]).replace('.',',')+' '+cfg[1];$('chartAvg').textContent=avg.toFixed(cfg[3]).replace('.',',')+' '+cfg[1];$('chartMax').textContent=Math.max(...vals).toFixed(cfg[3]).replace('.',',')+' '+cfg[1];stats.hidden=false}catch(e){canvas.className='chart-empty';canvas.innerHTML='Grafiek laden mislukt: '+esc(e.message);stats.hidden=true}}
try{theme(localStorage.getItem('datalogger-theme')||'light')}catch(e){theme('light')}
window.addEventListener('online',()=>setTimeout(retryArduinoConnection,250));
window.addEventListener('offline',()=>setTimeout(()=>{pollStatus()},250));
pollStatus();loadSessions();setInterval(pollStatus,1000);
</script></body></html>
)DATALOGGER";

// ---------- Helpers ----------
String sessionPath(uint32_t id){ char b[32]; snprintf(b,sizeof(b),"%s/S%04lu.CSV",LOG_DIR,(unsigned long)id); return String(b); }
String twoDigits(int v){ return (v<10?"0":"")+String(v); }
String formatDateTime(const DateTime &dt){ return String(dt.year())+"-"+twoDigits(dt.month())+"-"+twoDigits(dt.day())+" "+twoDigits(dt.hour())+":"+twoDigits(dt.minute())+":"+twoDigits(dt.second()); }
String formatTimeOnly(const DateTime &dt){ return twoDigits(dt.hour())+":"+twoDigits(dt.minute())+":"+twoDigits(dt.second()); }
uint32_t elapsedSessionMs(){ if(sessionState==STATE_RUNNING) return accumulatedRunMs + (uint32_t)(millis()-runStartedMs); return accumulatedRunMs; }
const char* stateName(){ return sessionState==STATE_RUNNING?"running":sessionState==STATE_PAUSED?"paused":"idle"; }
bool validArduinoFix(){ return gps.location.isValid() && gps.location.age()<5000 && gps.satellites.isValid() && gps.satellites.value()>0; }
bool validGpsUtc(){ return gps.date.isValid() && gps.time.isValid() && gps.date.age()<5000 && gps.time.age()<5000 && gps.date.year()>=2024 && gps.date.year()<=2100; }

bool selectedPosition(double &lat,double &lon,const char* &source){
  if(validArduinoFix()){
    lat=gps.location.lat();
    lon=gps.location.lng();
    source="Air530Z";
    return true;
  }
  source="Geen";
  lat=0;
  lon=0;
  return false;
}

void readGps(){ while(Serial1.available()){ char c=(char)Serial1.read(); gps.encode(c); gpsSeen=true; } }
void readSensors(){
  if(shtReady){float t=sht31.readTemperature(),h=sht31.readHumidity();if(!isnan(t))liveTemp=t;if(!isnan(h))liveHum=h;}
  uint32_t sum=0;const uint8_t N=12;for(uint8_t i=0;i<N;i++){sum+=analogRead(WIND_PIN);delayMicroseconds(250);}float adc=sum/(float)N;liveWindVoltage=adc*5.0f/4095.0f;liveWind=liveWindVoltage*6.0f;if(liveWind<0)liveWind=0;if(liveWind>30)liveWind=30;lastSensorReadMs=millis();
}


uint32_t findNextSessionId(){
  uint32_t maxId=0;if(!sdReady)return 1;File dir=SD.open(LOG_DIR);if(!dir)return 1;
  for(File f=dir.openNextFile();f;f=dir.openNextFile()){
    if(!f.isDirectory()){String n=String(f.name());int p=n.lastIndexOf('/');if(p>=0)n=n.substring(p+1);
      if(n.startsWith("S")&&n.endsWith(".CSV")){uint32_t id=(uint32_t)n.substring(1,n.length()-4).toInt();if(id>maxId)maxId=id;}}
    f.close();
  }dir.close();return maxId+1;
}
bool ensureLogDir(){if(SD.exists(LOG_DIR))return true;return SD.mkdir(LOG_DIR);}
void writeCsvHeader(File &f){
  f.println("measurement_id,rtc_datetime_local,elapsed_ms,temperature_C,humidity_pct,wind_speed_ms,wind_voltage_V,latitude,longitude,satellites,gps_fix,gps_speed_kmh,gps_utc,location_source");
  f.flush();
}
bool startSession(){
  if(sessionState!=STATE_IDLE||!sdReady)return false;if(!ensureLogDir())return false;
  sessionId=findNextSessionId();String path=sessionPath(sessionId);sessionFile=SD.open(path.c_str(),FILE_WRITE);if(!sessionFile)return false;
  writeCsvHeader(sessionFile);measurementCount=0;accumulatedRunMs=0;runStartedMs=millis();lastMeasureMs=millis()-intervalMs;lastFlushMs=millis();sessionState=STATE_RUNNING;return true;
}
void pauseSession(){if(sessionState==STATE_RUNNING){accumulatedRunMs+=(uint32_t)(millis()-runStartedMs);sessionState=STATE_PAUSED;if(sessionFile)sessionFile.flush();}}
void resumeSession(){if(sessionState==STATE_PAUSED){runStartedMs=millis();lastMeasureMs=millis()-intervalMs;sessionState=STATE_RUNNING;}}
void stopSession(){if(sessionState==STATE_RUNNING)accumulatedRunMs+=(uint32_t)(millis()-runStartedMs);if(sessionFile){sessionFile.flush();sessionFile.close();}sessionState=STATE_IDLE;}

void logMeasurement(){
  if(sessionState!=STATE_RUNNING||!sessionFile)return;readSensors();DateTime now=rtcReady?rtc.now():DateTime(2000,1,1,0,0,0);
  double lat=0,lon=0;const char* locSource;bool hasPos=selectedPosition(lat,lon,locSource);bool gpsFix=validArduinoFix();measurementCount++;
  sessionFile.print(measurementCount);sessionFile.print(',');sessionFile.print(formatDateTime(now));sessionFile.print(',');sessionFile.print(elapsedSessionMs());sessionFile.print(',');
  if(isnan(liveTemp))sessionFile.print("");else sessionFile.print(liveTemp,2);sessionFile.print(',');
  if(isnan(liveHum))sessionFile.print("");else sessionFile.print(liveHum,2);sessionFile.print(',');
  if(isnan(liveWind))sessionFile.print("");else sessionFile.print(liveWind,2);sessionFile.print(',');
  if(isnan(liveWindVoltage))sessionFile.print("");else sessionFile.print(liveWindVoltage,3);sessionFile.print(',');
  if(hasPos){sessionFile.print(lat,6);sessionFile.print(',');sessionFile.print(lon,6);}sessionFile.print(',');
  sessionFile.print(gps.satellites.isValid()?gps.satellites.value():0);sessionFile.print(',');sessionFile.print(gpsFix?1:0);sessionFile.print(',');
  if(gps.speed.isValid())sessionFile.print(gps.speed.kmph(),2);sessionFile.print(',');
  if(validGpsUtc()){char utc[24];snprintf(utc,sizeof(utc),"%04d-%02d-%02d %02d:%02d:%02d",gps.date.year(),gps.date.month(),gps.date.day(),gps.time.hour(),gps.time.minute(),gps.time.second());sessionFile.print(utc);}
  sessionFile.print(',');sessionFile.println(locSource);
  if((uint32_t)(millis()-lastFlushMs)>=1000){sessionFile.flush();lastFlushMs=millis();}
}

String queryValue(const String &url,const String &key){int q=url.indexOf('?');if(q<0)return "";String qs=url.substring(q+1),needle=key+"=";int p=0;while(p<qs.length()){int amp=qs.indexOf('&',p);if(amp<0)amp=qs.length();String part=qs.substring(p,amp);if(part.startsWith(needle))return part.substring(needle.length());p=amp+1;}return "";}
String routeOnly(const String &url){int q=url.indexOf('?');return q<0?url:url.substring(0,q);}
void sendHeaders(WiFiClient &c,int code,const char* type,int32_t length=-1,const char* extra=nullptr,const char* cacheControl="no-store"){
  c.print("HTTP/1.1 ");c.print(code);c.println(code==200?" OK":code==400?" Bad Request":code==404?" Not Found":" Error");
  c.print("Content-Type: ");c.println(type);if(length>=0){c.print("Content-Length: ");c.println(length);}if(extra)c.println(extra);c.print("Cache-Control: ");c.println(cacheControl);c.println("Connection: close");c.println();
}
void sendText(WiFiClient &c,int code,const String &v,const char* type="text/plain; charset=utf-8"){sendHeaders(c,code,type,v.length());c.print(v);}
void sendOk(WiFiClient &c){sendText(c,200,"OK");}
float estimateLoggedMB(){if(!sdReady)return -1;uint64_t bytes=0;File dir=SD.open(LOG_DIR);if(dir){for(File f=dir.openNextFile();f;f=dir.openNextFile()){if(!f.isDirectory())bytes+=f.size();f.close();}dir.close();}return max(0.0f,SD_NOMINAL_CAPACITY_MB-(float)bytes/1048576.0f);}

void sendStatus(WiFiClient &c){
  if((uint32_t)(millis()-lastSensorReadMs)>1000)readSensors();DateTime now=rtcReady?rtc.now():DateTime(2000,1,1,0,0,0);double lat=0,lon=0;const char* source;bool pos=selectedPosition(lat,lon,source);
  sendHeaders(c,200,"application/json; charset=utf-8");c.print('{');
  c.print("\"state\":\"");c.print(stateName());c.print("\",\"sessionId\":");c.print(sessionId);c.print(",\"elapsed\":");c.print(elapsedSessionMs()/1000.0,1);c.print(",\"count\":");c.print(measurementCount);c.print(",\"intervalMs\":");c.print(intervalMs);c.print(',');
  c.print("\"shtReady\":");c.print(shtReady?"true":"false");c.print(",\"temperature\":");if(isnan(liveTemp))c.print("null");else c.print(liveTemp,2);c.print(",\"humidity\":");if(isnan(liveHum))c.print("null");else c.print(liveHum,2);c.print(",\"windSpeed\":");if(isnan(liveWind))c.print("null");else c.print(liveWind,2);c.print(",\"windVoltage\":");if(isnan(liveWindVoltage))c.print("null");else c.print(liveWindVoltage,3);c.print(',');
  c.print("\"rtcReady\":");c.print(rtcReady?"true":"false");c.print(",\"rtcSynced\":");c.print(rtcSynced?"true":"false");c.print(",\"rtcTime\":\"");c.print(formatTimeOnly(now));c.print("\",\"sdReady\":");c.print(sdReady?"true":"false");c.print(",\"sdFreeMB\":");c.print(estimateLoggedMB(),1);c.print(',');
  c.print("\"gpsSeen\":");c.print(gpsSeen?"true":"false");c.print(",\"positionValid\":");c.print(pos?"true":"false");c.print(",\"satellites\":");c.print(gps.satellites.isValid()?gps.satellites.value():0);c.print(",\"latitude\":");c.print(lat,6);c.print(",\"longitude\":");c.print(lon,6);c.print(",\"locationSource\":\"");c.print(source);c.print("\"}");
}

bool parseCsvTimestamp(const String &line,DateTime &out){int a=line.indexOf(',');if(a<0)return false;int b=line.indexOf(',',a+1);if(b<0)return false;String v=line.substring(a+1,b);if(v.length()<19)return false;int y=v.substring(0,4).toInt(),mo=v.substring(5,7).toInt(),d=v.substring(8,10).toInt(),h=v.substring(11,13).toInt(),mi=v.substring(14,16).toInt(),se=v.substring(17,19).toInt();if(y<2020)return false;out=DateTime(y,mo,d,h,mi,se);return true;}
struct SessionMeta{uint32_t id=0,count=0,size=0,duration=0;String start="";};
bool sessionMetaFromFile(File &f,uint32_t id,SessionMeta &m){m.id=id;m.size=f.size();String line="";bool header=true,gotFirst=false,gotLast=false;DateTime first,last;while(f.available()){char ch=(char)f.read();if(ch=='\n'){line.trim();if(header)header=false;else if(line.length()){m.count++;DateTime dt;if(parseCsvTimestamp(line,dt)){if(!gotFirst){first=dt;gotFirst=true;m.start=formatDateTime(dt);}last=dt;gotLast=true;}}line="";}else if(ch!='\r'&&line.length()<260)line+=ch;}if(gotFirst&&gotLast){int64_t diff=(int64_t)last.unixtime()-(int64_t)first.unixtime();if(diff>0)m.duration=(uint32_t)diff;}f.seek(0);return true;}
void sendSessions(WiFiClient &c){sendHeaders(c,200,"application/json; charset=utf-8");c.print("{\"sessions\":[");bool firstOut=true;if(sdReady){File dir=SD.open(LOG_DIR);if(dir){for(File f=dir.openNextFile();f;f=dir.openNextFile()){if(!f.isDirectory()){String n=String(f.name());int p=n.lastIndexOf('/');if(p>=0)n=n.substring(p+1);if(n.startsWith("S")&&n.endsWith(".CSV")){uint32_t id=n.substring(1,n.length()-4).toInt();SessionMeta m;sessionMetaFromFile(f,id,m);if(!firstOut)c.print(',');firstOut=false;c.print("{\"id\":");c.print(m.id);c.print(",\"count\":");c.print(m.count);c.print(",\"size\":");c.print(m.size);c.print(",\"duration\":");c.print(m.duration);c.print(",\"start\":\"");c.print(m.start);c.print("\"}");}}f.close();}dir.close();}}c.print("]}");}
void sendDownload(WiFiClient &c,uint32_t id){if(!sdReady){sendText(c,404,"SD niet beschikbaar");return;}String path=sessionPath(id);File f=SD.open(path.c_str(),FILE_READ);if(!f){sendText(c,404,"Bestand niet gevonden");return;}String disp="Content-Disposition: attachment; filename=\"DataLogger_meetsessie_"+String(id)+".csv\"";sendHeaders(c,200,"text/csv; charset=utf-8",f.size(),disp.c_str());uint8_t buf[256];while(f.available()){int n=f.read(buf,sizeof(buf));if(n>0)c.write(buf,n);readGps();}f.close();}
void serveManual(WiFiClient &c){
  sendHeaders(c,200,"text/html; charset=utf-8",(int32_t)MANUAL_RAW_LEN,nullptr,"public, max-age=300");
  static uint8_t history[4096];
  uint32_t histPos=0;
  size_t ip=0;
  uint8_t outBuf[192];
  size_t outLen=0;
  auto emitByte=[&](uint8_t b){
    history[histPos & 4095]=b;
    histPos++;
    outBuf[outLen++]=b;
    if(outLen==sizeof(outBuf)){
      c.write(outBuf,outLen);
      outLen=0;
      readGps();
    }
  };
  while(ip<sizeof(MANUAL_LZ) && c.connected()){
    uint8_t ctrl=MANUAL_LZ[ip++];
    if((ctrl&0x80)==0){
      uint16_t n=(uint16_t)ctrl+1;
      for(uint16_t j=0;j<n && ip<sizeof(MANUAL_LZ);j++)emitByte(MANUAL_LZ[ip++]);
    }else{
      if(ip>=sizeof(MANUAL_LZ))break;
      uint8_t len=((ctrl>>4)&0x07)+3;
      uint16_t off=((uint16_t)(ctrl&0x0F)<<8)|MANUAL_LZ[ip++];
      for(uint8_t j=0;j<len;j++){
        uint8_t b=history[(histPos-off)&4095];
        emitByte(b);
      }
    }
  }
  if(outLen)c.write(outBuf,outLen);
  c.flush();
}

void serveHome(WiFiClient &c){const size_t total=sizeof(INDEX_HTML)-1;sendHeaders(c,200,"text/html; charset=utf-8",(int32_t)total,nullptr,"public, max-age=300");size_t sent=0;while(sent<total&&c.connected()){size_t n=min((size_t)768,total-sent);size_t w=c.write(reinterpret_cast<const uint8_t*>(INDEX_HTML)+sent,n);if(!w){delay(2);continue;}sent+=w;readGps();delay(1);}c.flush();}

void handleRequest(WiFiClient &c,const String &url,const String &method){
  String route=routeOnly(url);if(route=="/handleiding"){serveManual(c);return;}if(route=="/"){serveHome(c);return;}if(route=="/ping"){sendText(c,200,"DataLogger OK");return;}if(route=="/api/status"||route=="/status"){sendStatus(c);return;}if(route=="/api/sessions"||route=="/sessions"){sendSessions(c);return;}
  if(route=="/api/start"){if(startSession())sendOk(c);else sendText(c,400,"Starten mislukt");return;}if(route=="/api/pause"){if(sessionState==STATE_RUNNING){pauseSession();sendOk(c);}else sendText(c,400,"Niet actief");return;}if(route=="/api/resume"){if(sessionState==STATE_PAUSED){resumeSession();sendOk(c);}else sendText(c,400,"Niet gepauzeerd");return;}if(route=="/api/stop"){if(sessionState!=STATE_IDLE){stopSession();sendOk(c);}else sendText(c,400,"Geen actieve sessie");return;}
  if(route=="/api/interval"){long ms=queryValue(url,"ms").toInt();if(ms>=500&&ms<=2147483000L){intervalMs=(uint32_t)ms;sendOk(c);}else sendText(c,400,"Interval minimaal 0,5 s");return;}
  if(route=="/api/time"){int y=queryValue(url,"y").toInt(),mo=queryValue(url,"mo").toInt(),d=queryValue(url,"d").toInt(),h=queryValue(url,"h").toInt(),mi=queryValue(url,"mi").toInt(),se=queryValue(url,"s").toInt();if(rtcReady&&y>=2024&&mo>=1&&mo<=12&&d>=1&&d<=31&&h<24&&mi<60&&se<60){rtc.adjust(DateTime(y,mo,d,h,mi,se));rtcSynced=true;sendOk(c);}else sendText(c,400,"Ongeldige tijd");return;}
  if(route=="/api/delete"){uint32_t id=queryValue(url,"id").toInt();String p=sessionPath(id);if(sdReady&&SD.exists(p.c_str())&&SD.remove(p.c_str()))sendOk(c);else sendText(c,404,"Bestand niet gevonden");return;}
  if(route=="/api/download"){sendDownload(c,queryValue(url,"id").toInt());return;}sendText(c,404,"Niet gevonden");
}
void handleWebClient(){WiFiClient c=server.available();if(!c)return;c.setTimeout(1200);uint32_t started=millis();String line="";while(c.connected()&&(uint32_t)(millis()-started)<2000){readGps();if(c.available()){char ch=(char)c.read();if(ch=='\n')break;if(ch!='\r'&&line.length()<500)line+=ch;}else delay(1);}if(line.length()){int s1=line.indexOf(' '),s2=line.indexOf(' ',s1+1);if(s1>0&&s2>s1){String method=line.substring(0,s1),url=line.substring(s1+1,s2);while(c.connected()&&c.available()){String h=c.readStringUntil('\n');if(h=="\r"||h.length()<=1)break;}handleRequest(c,url,method);}}delay(2);c.stop();}

void setup(){
  Serial.begin(115200);delay(200);Wire.begin();Serial1.begin(GPS_BAUD);analogReadResolution(12);pinMode(WIND_PIN,INPUT);
  rtcReady=rtc.begin();if(rtcReady){if(!rtc.isrunning()){rtc.adjust(DateTime(F(__DATE__),F(__TIME__)));rtcSynced=false;}else{DateTime n=rtc.now();rtcSynced=n.year()>=2024&&n.year()<=2100;}}
  shtReady=sht31.begin(0x44);sdReady=SD.begin(SD_CS_PIN);if(sdReady)ensureLogDir();readSensors();
  WiFi.beginAP(WIFI_SSID,WIFI_PASS);delay(500);server.begin();
  Serial.println("\nDataLogger Toolkit 3 gestart");Serial.print("SHT31: ");Serial.println(shtReady?"actief":"niet gevonden");Serial.print("Open: http://");Serial.println(WiFi.localIP());
}
void loop(){
  readGps();uint32_t now=millis();
  if(sessionState==STATE_RUNNING&&(uint32_t)(now-lastMeasureMs)>=intervalMs){lastMeasureMs+=intervalMs;logMeasurement();}
  else if(sessionState!=STATE_RUNNING&&(uint32_t)(now-lastSensorReadMs)>=1000)readSensors();
  handleWebClient();
}
